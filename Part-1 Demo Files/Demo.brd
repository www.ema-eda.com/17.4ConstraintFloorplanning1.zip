# Allegro board Demo.brd (continued)
## Nets (continued)
S_DIG_2_E: RN18.12 U15.AD22 U26.32
S_DIG_2_F: RN18.11 U15.AB21 U26.33
S_DIG_2_G: RN18.10 U15.AA21 U26.35
S_DIP<0>: RN37.10 U15.AC23
S_DIP<1>: RN38.16 U15.AD24
S_DIP<2>: RN38.14 U15.AD23
S_DIP<3>: RN38.12 U15.AG24
S_DIP<4>: RN38.10 U15.AE24
S_DIP<5>: RN38.9(2) U15.AE23
S_DIP<6>: RN39.16 U15.AF24
S_DIP<7>: RN39.15 U15.AC22
S_DP_A: RN34.8 U26.2
S_DP_B: RN33.8 U26.13
S_E_A: RN34.5 U26.6
S_E_B: RN33.5 U26.17
S_EPC16_CEN: U15.V23 U29.78
S_EPC16_OEN: U15.Y26 U29.80
S_EPC16_RPN: U15.W28 U29.39 U29.72
S_EPC16_WEN: U15.V24 U29.33 U29.38
S_F_A: RN34.6 U26.5
S_F_B: RN33.6 U26.16
S_G_A: RN34.7 U26.3
S_G_B: RN33.7 U26.14
S_HEADER<0>: J68.1 U15.AA29
S_HEADER<1>: J68.3 U15.AA28
S_HEADER<2>: J68.5 U15.AB30
S_HEADER<3>: J68.7 U15.AB31
S_HEADER<4>: J68.9 U15.AA30
S_HEADER<5>: J68.11 U15.AA31
S_HEADER<6>: J68.13 U15.Y29
S_HEADER<7>: J68.15 U15.Y30
S_HEADER<8>: J68.17 U15.Y31
S_HEADER<9>: J68.19 U15.Y32
S_HEADER<10>: J68.20 U15.W29
S_HEADER<11>: J68.18 U15.W30
S_HEADER<12>: J68.16 U15.W31
S_HEADER<13>: J68.14 U15.W32
S_HEADER<14>: J68.12 U15.V29
S_HEADER<15>: J68.10 U15.V30
S_HEADER<16>: J68.8 U15.V31
S_HEADER<17>: J68.6 U15.V32
S_HEADER<18>: J68.4 U15.Y23
S_HEADER<19>: J68.2 U15.Y25
S_LED<0>: RN19.9(2) U15.AB22 U34.47
S_LED<1>: RN19.10 U15.AF23 U34.46
S_LED<2>: RN19.11 U15.AM29 U34.44
S_LED<3>: RN19.12 U15.AL29 U34.43
S_LED<4>: RN19.13 U15.AL30 U34.41
S_LED<5>: RN19.14 U15.AK29 U34.40
S_MICTOR_EP_<0>: J75.37 U15.AL20
S_MICTOR_EP_<1>: J75.35 U15.AK20
S_MICTOR_EP_<2>: J75.33 U15.AH20
S_MICTOR_EP_<3>: J75.31 U15.AL21
S_MICTOR_EP_<4>: J75.29 U15.AK21
S_MICTOR_EP_<5>: J75.27 U15.AJ21
S_MICTOR_EP_<6>: J75.25 U15.AM22
S_MICTOR_EP_<7>: J75.23 U15.AJ20
S_MICTOR_EP_<8>: J75.21 U15.AL22
S_MICTOR_EP_<9>: J75.19 U15.AK22
S_MICTOR_EP_<10>: J75.17 U15.AL23
S_MICTOR_EP_<11>: J75.15 U15.AK23
S_MICTOR_EP_<12>: J75.13 U15.AM24
S_MICTOR_EP_<13>: J75.11 U15.AH22
S_MICTOR_EP_<14>: J75.9 U15.AL24
S_MICTOR_EP_<15>: J75.7 U15.AJ23
S_MICTOR_EP_CLK: J75.5 U15.AM20
S_MICTOR_OP_<0>: J75.38 U15.AM26
S_MICTOR_OP_<1>: J75.36 U15.AM25
S_MICTOR_OP_<2>: J75.34 U15.AK24
S_MICTOR_OP_<3>: J75.32 U15.AL25
S_MICTOR_OP_<4>: J75.30 U15.AK25
S_MICTOR_OP_<5>: J75.28 U15.AJ25
S_MICTOR_OP_<6>: J75.26 U15.AL28
S_MICTOR_OP_<7>: J75.24 U15.AJ27
S_MICTOR_OP_<8>: J75.22 U15.AJ24
S_MICTOR_OP_<9>: J75.20 U15.AH24
S_MICTOR_OP_<10>: J75.18 U15.AL26
S_MICTOR_OP_<11>: J75.16 U15.AK26
S_MICTOR_OP_<12>: J75.14 U15.AM28
S_MICTOR_OP_<13>: J75.12 U15.AM27
S_MICTOR_OP_<14>: J75.10 U15.AJ26
S_MICTOR_OP_<15>: J75.8 U15.AK27
S_MICTOR_OP_CLK: J75.6 U15.AJ22
S_OVERTEMPN: U12.9 U15.B14
S_PB0_IN: C654.1 R180.2 RN14.11 U43.3
S_PB1_IN: C651.1 R181.2 RN14.9(2) U43.12
S_PB2_IN: C645.1 R182.2 RN37.16 U43.5
S_PB3_IN: C644.1 R183.2 RN37.15 U43.10
S_PB<0>: R180.1 U15.AB20 U43.13
S_PB<1>: R181.1 U15.AG22 U43.4
S_PB<2>: R182.1 U15.AB24 U43.11
S_PB<3>: R183.1 U15.AC24 U43.6
S_PB_DEV_CLR_N: R171.1 U15.AH14 U34.29 U43.2
S_PB_DEV_CLR_N_IN: C656.1 R171.2 RN14.13 U43.14
S_PGM0: U15.AD18 U21.2
S_PGM1: U15.AG14 U21.3
S_PGM2: U15.AA20 U21.4
S_PLL_ENA: R119.1 U15.AF19
S_RS232_CTS: R169.2 U15.Y28 U33.9
S_RS232_RTS: R170.2 U15.W23 U33.10
S_RS232_RXD: U15.Y27 U33.12
S_RS232_TXD: U15.W24 U33.11
S_RUNLU: R148.1 U15.AF14 U20.25 U21.35
S_RX1IN1: J124.3 U33.13
S_RX2IN1: J124.7 U33.8
S_SMB_CLK: U12.14 U15.J15
S_SMB_DATA: U12.12 U15.J14
S_STATUS_BUF_N: R158.1 U15.G16 U19.25 U19.32
S_TDI1: U15.D16
S_TDO1_SW: U15.F16
S_TEMPDIODEN: U12.4 U15.E18
S_TEMPDIODEP: U12.3 U15.F18
S_TX1OUT1: J124.2 U33.14
S_TX2OUT1: J124.8 U33.7
S_USER_LED1: RN21.8 U34.2
S_USER_LED2: RN21.7 U34.3
S_USER_LED3: RN21.6 U34.5
S_USER_LED4: RN21.5 U34.6
S_USER_LED5: RN21.4 U34.8
S_USER_LED6: RN21.3 U34.9
S_VCCSEL: R120.1 U15.AJ14
SCRUZ_CARDSELN: J92.38 R134.1 U15.B3 U22.23 U23.23 U24.23 U39.23 U52.23
SCRUZ_CLK_OSC_A: J78.9 R261.2 U15.AJ17
SCRUZ_IO<0>: U15.A11 U24.2
SCRUZ_IO<1>: U15.B12 U24.3
SCRUZ_IO<2>: U15.C12 U24.4
SCRUZ_IO<3>: U15.C13 U24.5
SCRUZ_IO<4>: U15.D13 U24.6
SCRUZ_IO<5>: U15.E13 U24.7
SCRUZ_IO<6>: U15.A13 U24.8
SCRUZ_IO<7>: U15.B13 U24.9
SCRUZ_IO<8>: U15.D12 U24.10
SCRUZ_IO<9>: U15.E11 U24.11
SCRUZ_IO<10>: U15.B9 U23.2
SCRUZ_IO<11>: U15.D10 U23.3
SCRUZ_IO<12>: U15.C10 U23.4
SCRUZ_IO<13>: U15.A9 U23.5
SCRUZ_IO<14>: U15.B11 U23.6
SCRUZ_IO<15>: U15.C11 U23.7
SCRUZ_IO<16>: U15.B10 U23.8
SCRUZ_IO<17>: U15.D11 U23.9
SCRUZ_IO<18>: U15.B7 U23.10
SCRUZ_IO<19>: U15.D8 U23.11
SCRUZ_IO<20>: U15.B8 U22.2
SCRUZ_IO<21>: U15.E9 U22.3
SCRUZ_IO<22>: U15.A8 U22.4
SCRUZ_IO<23>: U15.C9 U22.5
SCRUZ_IO<24>: U15.C8 U22.6
SCRUZ_IO<25>: U15.D9 U22.7
SCRUZ_IO<26>: U15.A7 U22.8
SCRUZ_IO<27>: U15.D6 U22.9
SCRUZ_IO<28>: U15.C6 U22.10
SCRUZ_IO<29>: U15.B5 U22.11
SCRUZ_IO<30>: U15.C7 U39.2
SCRUZ_IO<31>: U15.A5 U39.3
SCRUZ_IO<32>: U15.D7 U39.4
SCRUZ_IO<33>: U15.A6 U39.5
SCRUZ_IO<34>: U15.B6 U39.6
SCRUZ_IO<35>: U15.E7 U39.7
SCRUZ_IO<36>: U15.D5 U39.8
SCRUZ_IO<37>: U15.C3 U39.9
SCRUZ_IO<38>: U15.E5 U39.10
SCRUZ_IO<39>: U15.C4 U39.11
SCRUZ_SYS_RESETN: J92.1 U15.C5
SFP0_MOD_DEF4_<0>: J54.6 R226.2 U7.AG22
SFP0_MOD_DEF4_<1>: J54.5 R227.2 U7.AG20
SFP0_MOD_DEF4_<2>: J54.4 R228.2 U7.AG19
SFP0_RATE_SELECT4: J54.7 U7.AG18
SFP0_RX_LOS4: J54.8 R224.2 U7.AF22
SFP0_TX_DISABLE4: J54.3 R174.2 U7.AG17
SFP0_TX_FAULT4: J54.2 R229.2 U7.AF23
SFP1_MOD_DEF5_<0>: J64.6 R235.2 U7.AF20
SFP1_MOD_DEF5_<1>: J64.5 R237.2 U7.AF19
SFP1_MOD_DEF5_<2>: J64.4 R239.2 U7.AE23
SFP1_RATE_SELECT5: J64.7 U7.AE22
SFP1_RX_LOS5: J64.8 R230.2 U7.AE19
SFP1_TX_DISABLE5: J64.3 R173.2 U7.AE21
SFP1_TX_FAULT5: J64.2 R241.2 U7.AE20
SFP2_MOD_DEF6_<0>: J45.6 R218.2 U7.AD22
SFP2_MOD_DEF6_<1>: J45.5 R219.2 U7.AD21
SFP2_MOD_DEF6_<2>: J45.4 R220.2 U7.AD20
SFP2_RATE_SELECT6: J45.7 U7.AD19
SFP2_RX_LOS6: J45.8 R217.2 U7.AC21
SFP2_TX_DISABLE6: J45.3 R162.2 U7.AD18
SFP2_TX_FAULT6: J45.2 R221.2 U7.AC22
SFP3_MOD_DEF7_<0>: J38.6 R206.2 U7.AC19
SFP3_MOD_DEF7_<1>: J38.5 R209.2 U7.AC18
SFP3_MOD_DEF7_<2>: J38.4 R210.2 U7.AC17
SFP3_RATE_SELECT7: J38.7 U7.AB21
SFP3_RX_LOS7: J38.8 R205.2 U7.AB18
SFP3_TX_DISABLE7: J38.3 R161.2 U7.AB20
SFP3_TX_FAULT7: J38.2 R211.2 U7.AB19
SFP_VCCR1_4: C60.1 C430.1 J54.15
SFP_VCCR1_5: C77.1 C464.1 J64.15
SFP_VCCR1_6: C52.1 C352.1 J45.15
SFP_VCCR1_7: C50.1 C282.1 J38.15
SFP_VCCT1_4: C433.1 J54.16
SFP_VCCT1_5: C493.1 J64.16
SFP_VCCT1_6: C363.1 J45.16
SFP_VCCT1_7: C297.1 J38.16
SMA_INPUT1_TO_SGX_N: J60.1(OUTPUT) R322.2
SMA_INPUT1_TO_SGX_P: J52.1(OUTPUT) R322.1
SMA_INPUT2_TO_SGX_N: J16.1(OUTPUT)
SMA_INPUT2_TO_SGX_P: J24.1(OUTPUT)
SMA_INPUT3_TO_SGX_N: J121.1(OUTPUT)
SMA_INPUT3_TO_SGX_P: J122.1(OUTPUT)
SMA_INPUT4_TO_SGX_N: J123.2(4) U7.AA4
SMA_INPUT4_TO_SGX_P: J123.1 U7.AA3
SPGM0: R292.1 U20.28 U21.38 U29.14
SPGM1: R293.1 U20.27 U21.37 U29.13
SPGM2: R294.1 U20.26 U21.36 U29.15
STX_PMC_CLK: U15.A19 U15.AJ16
STX_PMC_GNTN: U15.C21 U15.C30
STX_PMC_REQN: U15.B21 U15.B30
TCK: J87.1 R56.1 U15.G14 U29.35 U30.35
TDI1: J87.9 R160.1
TDO: J87.3 U30.44
TDO1_EPC16: U29.44 U30.42
TEMPDIODEN: U7.B3
TEMPDIODEP: U7.G9
TMS: J87.5 R41.1 U15.E15 U29.48 U30.48
TP10: U7.AE10
TP11: U7.AF12
TP12: U7.AB11
TP13: U7.AG11
TP17: U7.AF10
TP21: U15.V27
TP22: U15.V28
TP23: U15.W27
TP24: U15.W26
TP25: U15.W25
TP29: U15.AE15
TP69: R358.2 U29.37
TP70: R359.2 U30.37
TRIG_155_52_N: R347.2 U18.11 U47.3
TRIG_155_52_P: R347.1 U18.12 U47.2
TRIG_156_25: J97.1(OUTPUT) U46.7
TRIG_156_25_N: R346.2 U32.11 U46.3
TRIG_156_25_P: R346.1 U32.12 U46.2
TRSTN: R44.1 U15.G15
VEND_SPECIFIC0: R333.1 R334.2 R341.2 U27.11
VEND_SPECIFIC1: R332.1 R335.2 R340.2 U27.15
VEND_SPECIFIC2: R331.1 R336.2 R339.2 U27.16
VEND_SPECIFIC3: R330.1 R337.2 R338.2 U27.24(VEND3)
VREF_DIMM: XU2.1
XCVR_RX_N0C: C115.1 J98.1(OUTPUT)
XCVR_RX_N1C: C101.1 J81.1(OUTPUT)
XCVR_RX_N2C: C25.1 J27.1(OUTPUT)
XCVR_RX_N3C: C24.1 J26.1(OUTPUT)
XCVR_RX_N8C: C1.1 J1.6A
XCVR_RX_N9C: C3.1 J1.6C
XCVR_RX_N10C: C5.1 J1.6E
XCVR_RX_N11C: C7.1 J1.6G
XCVR_RX_N16C: C22.1 J23.2
XCVR_RX_N17C: C29.1 J32.2
XCVR_RX_N18C: C17.1 J15.2
XCVR_RX_N19C: C10.1 J11.2
XCVR_RX_N<0>: C115.2 U7.M4
XCVR_RX_N<1>: C101.2 U7.M2
XCVR_RX_N<2>: C25.2 U7.L4
XCVR_RX_N<3>: C24.2 U7.L2
XCVR_RX_N<4>: J54.12 U7.R3
XCVR_RX_N<5>: J64.12 U7.N5
XCVR_RX_N<6>: J45.12 U7.N3
XCVR_RX_N<7>: J38.12 U7.P2
XCVR_RX_N<8>: C1.2 U7.K4
XCVR_RX_N<9>: C3.2 U7.K2
XCVR_RX_N<10>: C5.2 U7.J4
XCVR_RX_N<11>: C7.2 U7.J2
XCVR_RX_N<12>: U7.H2 U27.42
XCVR_RX_N<13>: U7.G4 U27.45
XCVR_RX_N<14>: U7.G2 U27.48
XCVR_RX_N<15>: U7.F4 U27.51
XCVR_RX_N<16>: C22.2 U7.F2
XCVR_RX_N<17>: C29.2 U7.E4
XCVR_RX_N<18>: C17.2 U7.E2
XCVR_RX_N<19>: C10.2 U7.D2
XCVR_RX_P0C: C105.1 J93.1(OUTPUT)
XCVR_RX_P1C: C104.1 J86.1(OUTPUT)
XCVR_RX_P2C: C20.1 J19.1(OUTPUT)
XCVR_RX_P3C: C21.1 J18.1(OUTPUT)
XCVR_RX_P8C: C2.1 J1.6B
XCVR_RX_P9C: C4.1 J1.6D
XCVR_RX_P10C: C6.1 J1.6F
XCVR_RX_P11C: C8.1 J1.6H
XCVR_RX_P16C: C23.1 J23.3
XCVR_RX_P17C: C32.1 J32.3
XCVR_RX_P18C: C18.1 J15.3
XCVR_RX_P19C: C11.1 J11.3
XCVR_RX_P<0>: C105.2 U7.M3
XCVR_RX_P<1>: C104.2 U7.M1
XCVR_RX_P<2>: C20.2 U7.L3
XCVR_RX_P<3>: C21.2 U7.L1
XCVR_RX_P<4>: J54.13 U7.R2
XCVR_RX_P<5>: J64.13 U7.N4
XCVR_RX_P<6>: J45.13 U7.N2
XCVR_RX_P<7>: J38.13 U7.P1
XCVR_RX_P<8>: C2.2 U7.K3
XCVR_RX_P<9>: C4.2 U7.K1
XCVR_RX_P<10>: C6.2 U7.J3
XCVR_RX_P<11>: C8.2 U7.J1
XCVR_RX_P<12>: U7.H1 U27.41
XCVR_RX_P<13>: U7.G3 U27.44
XCVR_RX_P<14>: U7.G1 U27.47
XCVR_RX_P<15>: U7.F3 U27.50
XCVR_RX_P<16>: C23.2 U7.F1
XCVR_RX_P<17>: C32.2 U7.E3
XCVR_RX_P<18>: C18.2 U7.E1
XCVR_RX_P<19>: C11.2 U7.D1
XCVR_TX_N<0>: J77.1(OUTPUT) U7.R7
XCVR_TX_N<1>: J105.1(OUTPUT) U7.R5
XCVR_TX_N<2>: J28.1(OUTPUT) U7.R11
XCVR_TX_N<3>: J25.1(OUTPUT) U7.P9
XCVR_TX_N<4>: J54.19 U7.L9
XCVR_TX_N<5>: J64.19 U7.J9
XCVR_TX_N<6>: J45.19 U7.T6
XCVR_TX_N<7>: J38.19 U7.T10
XCVR_TX_N<8>: J1.5B U7.P7
XCVR_TX_N<9>: J1.5D U7.P5
XCVR_TX_N<10>: J1.5F U7.P11
XCVR_TX_N<11>: J1.5H U7.N9
XCVR_TX_N<12>: U7.N7 U27.56
XCVR_TX_N<13>: U7.M9 U27.59
XCVR_TX_N<14>: U7.M7 U27.62
XCVR_TX_N<15>: U7.M11 U27.65
XCVR_TX_N<16>: J23.6 U7.L8
XCVR_TX_N<17>: J32.6 U7.L6
XCVR_TX_N<18>: J15.6 U7.K9
XCVR_TX_N<19>: J11.6 U7.K7
XCVR_TX_P<0>: J72.1(OUTPUT) U7.R6
XCVR_TX_P<1>: J101.1(OUTPUT) U7.R4
XCVR_TX_P<2>: J20.1(OUTPUT) U7.R10
XCVR_TX_P<3>: J17.1(OUTPUT) U7.P8
XCVR_TX_P<4>: J54.18 U7.L10
XCVR_TX_P<5>: J64.18 U7.J8
XCVR_TX_P<6>: J45.18 U7.T5
XCVR_TX_P<7>: J38.18 U7.T11
XCVR_TX_P<8>: J1.5A U7.P6
XCVR_TX_P<9>: J1.5C U7.P4
XCVR_TX_P<10>: J1.5E U7.P10
XCVR_TX_P<11>: J1.5G U7.N8
XCVR_TX_P<12>: U7.N6 U27.55
XCVR_TX_P<13>: U7.M8 U27.58
XCVR_TX_P<14>: U7.M6 U27.61
XCVR_TX_P<15>: U7.M10 U27.64
XCVR_TX_P<16>: J23.5(TX_P) U7.L7
XCVR_TX_P<17>: J32.5(TX_P) U7.L5
XCVR_TX_P<18>: J15.5(TX_P) U7.K8
XCVR_TX_P<19>: J11.5(TX_P) U7.K6
XPAK_LASI: R105.2 R258.1 U7.AG14 U27.9
XPAK_MDC: J63.5 R109.2 R254.1 U27.18
XPAK_MDIN: J63.9 R101.1
XPAK_MDIO: J63.7 R101.2 R108.2 R255.1 U27.17
XPAK_MOD_DET: R122.2 U7.AG15 U27.14
XPAK_PRTAD<0>: R114.2 R249.1 U7.AG10 U27.23
XPAK_PRTAD<1>: R113.2 R250.1 U7.AH16 U27.22
XPAK_PRTAD<2>: R112.2 R251.1 U7.AH7 U27.21
XPAK_PRTAD<3>: R111.2 R252.1 U7.AH6 U27.20
XPAK_PRTAD<4>: R110.2 R253.1 U7.AH9 U27.19
XPAK_TX_ON: R107.2 R256.1 U7.AG12 U27.12
XPAK_VEND<0>: R334.1 U7.AH8
XPAK_VEND<1>: R335.1 U7.AH11
XPAK_VEND<2>: R336.1 U7.AG9
XPAK_VEND<3>: R337.1 U7.AG8
XPAK_X_RST: R106.2 R257.1 U7.AG13 U27.10
XTAL1_SGX_INT_N: C107.1 R167.2 U32.19
XTAL1_SGX_INT_P: C106.1 R167.1 U32.20
XTAL1_SGX_N: C107.2 R16.2 R195.2
XTAL1_SGX_P: C106.2 R15.2 R196.1
XTAL1_STX_INT_N: C109.1 R168.2 U32.16
XTAL1_STX_INT_P: C108.1 R168.1 U32.17
XTAL1_STX_N: C109.2 R87.2 R88.2 U15.T30
XTAL1_STX_P: C108.2 R89.2 R90.2 U15.T29
XTAL1_TP_N: R165.2 U32.14
XTAL1_TP_P: R165.1 U32.15
XTAL2_SGX_INT_N: C97.1 R137.2 U18.19
XTAL2_SGX_INT_P: C96.1 R137.1 U18.20
XTAL2_SGX_N: C97.2 R191.2 R192.2
XTAL2_SGX_P: C96.2 R193.2 R194.2
XTAL2_STX_INT_N: C99.1 R138.2 U18.16
XTAL2_STX_INT_P: C98.1 R138.1 U18.17
XTAL2_STX_N: C99.2 R91.2 R92.2 U15.T28
XTAL2_STX_P: C98.2 R93.2 R94.2 U15.T27
XTAL2_TP_N: R135.2 U18.14
XTAL2_TP_P: R135.1 U18.15
XTAL3_OUT_SGX: R345.1 U13.6
XTAL3_OUT_SGX_N: R345.2 R348.2
XTAL3_OUT_STX: U13.5 U15.AK19
XTAL3_OUT_TP1: J69.1(OUTPUT) U13.7
XTAL3_OUT_TP2: U13.8
N16695485: J124.1 J124.4 J124.6
N16771186: R116.1 R118.1 U11.18
N16771204: C94.1 R129.2 RJ1.13 RJ1.14
N16771208: C94.2 RJ1.8
N16771572: R103.1 R104.1 U11.17
N16771620: C83.2 R104.2 R116.2
N16771734: R259.1 U11.20
N16827057: R264.2 U26.48
N16827063: R263.2 U26.24
N16827184: R265.2 U26.1
N16827202: R262.2 U26.25
N16873824: R266.2 U25.25
N16874052: R267.2 U25.24
N16874056: R268.2 U25.48
N16874162: R269.2 U25.1
N16874692: RN36.16
N16874694: RN36.15
N16874698: RN36.14
N16874700: RN36.13
N16874702: RN36.12
N16874704: RN36.11
N16874706: RN36.10
N16874715: RN36.9(2)
N16874738: RN35.16
N16874740: RN35.15
N16874745: RN35.14
N16874747: RN35.13
N16874749: RN35.12
N16874754: RN35.11
N16874756: RN35.10
N16874758: RN35.9(2)
N17102164: RN33.16
N17102165: RN33.15
N17102167: RN33.14
N17102168: RN33.13
N17102169: RN33.12
N17102171: RN33.11
N17102172: RN33.10
N17102173: RN33.9(2)
N17102479: RN34.15
N17102484: RN34.9(2)
N17102491: RN34.12
N17102495: RN34.13
N17102503: RN34.16
N17102508: RN34.11
N17102509: RN34.14
N18367160: U20.12
N18367161: U20.13
N18367162: U20.14
N18368499: U20.17
N18368500: U20.18
N18368501: U20.19
N18445704: R140.2 U30.66
N24962500: R297.1 R298.2 U42.5

Pads without a net: CON3 40; ISO1 3 4 5 6; J1 1A 1B 1C 1D 1E 1F 1G 1H 2A 2B 2C 2D 2E 2F 2G 2H 3A 3B 3C 3D 3E 3F 3G 3H 4A 4B 4C 4D 4E 4F 4G 4H 7A 7B 7C 7D 7E 7F 7G 7H 8A 8B 8C 8D 8E 8F 8G 8H 9A 9B 9C 9D 9E 9F 9G 9H 10A 10B 10C 10D 10E 10F 10G 10H; J4 4; J31 5 18; J34 1 2 3 4; J36 1 3 5 7; J57 A27 B27; J58 A27 B27; J63 1 3 6 8; J75 1 2 3 4; J78 3 15 17 19; J79 2 3; J85 8; J87 7 8; J92 20; J108 1BG 5B 8H; J109 1A 1B 1E 1F 1G 1H 2A 2B 2E 2F 2G 2H 3A 3B 3C 3D 3E 3F 3G 3H 4A 4B 4C 4D 4E 4F 4G 4H 5C 5D 5E 5F 5G 5H 6A 6B 6C 6D 6E 6F 6G 6H 7A 7B 7C 7D 7E 7F 7G 7H 8A 8B 8C 8D 8E 8F 9A 9B 9C 9D 9E 9F 10A 10B 10C 10D 10E 10F; J124 9 18; PMCJN1 1 10 42 64; PMCJN2 3 4 5 8 9 10 17 34 52 54 55 57 58 60 61 64; RJ1 5 7; RN20 1 2 8 9 15 16; RN22 8 9; RN27 8 9; RN39 3 4 5 6 7 8 9 10 11 12 13 14; U4 4; U5 5 13 16; U6 2 6 7 10 16 17 18 19; U7 A3 A15 A16 A17 A18 A19 A30 AA1 AA2 AA5 AA6 AA7 AA8 AA9 AA10 AA11 AA16 AA17 AA22 AA23 AA28 AA29 AA30 AA31 AA32 AB1 AB2 AB3 AB4 AB5 AB6 AB7 AB8 AB9 AB10 AB27 AB28 AC1 AC2 AC3 AC4 AC6 AC7 AC8 AC9 AC11 AC13 AC23 AC29 AC30 AD1 AD2 AD3 AD4 AD5 AD6 AD7 AD8 AD9 AD28 AD29 AD30 AE1 AE2 AE3 AE4 AE5 AE6 AE9 AE24 AF1 AF2 AF3 AF4 AF5 AF6 AF8 AF11 AF13 AF14 AF15 AF16 AF24 AF27 AF28 AG1 AG2 AG3 AG4 AG5 AG21 AG25 AG28 AH1 AH2 AH3 AH4 AH12 AH15 AH17 AH18 AH19 AH20 AH21 AJ1 AJ2 AJ3 AJ4 AJ9 AJ15 AJ16 AJ17 AJ18 AJ24 AJ29 AJ30 AK1 AK2 AK3 AK14 AK15 AK16 AK17 AK18 AK19 AK30 AK31 AK32 AL2 AL3 AL15 AL16 AL17 AL18 AL19 AL30 AL31 AM3 AM15 AM16 AM17 AM18 AM19 AM30 B2 B6 B9 B12 B16 B17 B18 B19 B22 B24 B26 B30 B31 C1 C2 C3 C5 C7 C11 C14 C17 C18 C19 C29 C30 C31 C32 D3 D4 D9 D17 D18 D20 D24 D29 D30 D31 D32 E9 E12 E14 E17 E18 E21 E29 E30 F5 F6 F12 F14 F16 F17 F18 F19 F20 F21 F24 F25 F28 G5 G6 G14 G19 G23 G24 G25 G27 G28 H3 H4 H5 H6 H9 H10 H12 H19 H20 H21 H23 H24 H27 H28 J5 J6 J7 J10 J12 J13 J15 J16 J17 J23 J25 J26 J27 J28 J29 J30 K11 K15 K16 K17 K24 K25 L12 L16 L17 L22 L27 L28 M5 M16 M17 M28 N10 N11 P3 P22 P23 P30 R1 R32 T1 T2 T3 T4 T12 T21 T29 T31 T32 U1 U2 U3 U4 U5 U6 U10 U11 U12 U21 U29 U30 U31 U32 V1 V2 V3 V4 V5 V6 V7 V9 V10 V32 W1 W2 W3 W4 W5 W6 W7 W8 W9 W10 W11 W22 W23 W30 Y4 Y5 Y6 Y7 Y8 Y9; U9 1 4 6; U10 1 10 12 14 16 21 23 28 30; U11 2 3 4 5 7 8 9 10 25 26 27 28 47 109 111 112 113 114 115 116 118 119 121 122 123 124 125 126 128; U12 5 13 16; U15 A4 A14 A16 A17 A18 A26 AA6 AA7 AA8 AA9 AA11 AA13 AA14 AA15 AA18 AA19 AA22 AB6 AB7 AB9 AB10 AB12 AB14 AB15 AB18 AB23 AC5 AC6 AC7 AC8 AC10 AC11 AC14 AC15 AC18 AC19 AD1 AD2 AD5 AD6 AD7 AD8 AD10 AD11 AD15 AE5 AE6 AE7 AE8 AE10 AE14 AE21 AE22 AF5 AF6 AF7 AF8 AF11 AF12 AF13 AF21 AG5 AG7 AG8 AG13 AG19 AG25 AG26 AG28 AH1 AH2 AH4 AH7 AH11 AH13 AH26 AH28 AH29 AH31 AH32 AJ9 AJ10 AJ11 AJ12 AJ13 AJ28 AJ29 AK5 AK8 AK9 AK10 AK11 AK12 AK13 AK14 AK16 AK17 AK28 AK30 AL8 AL9 AL10 AL11 AL12 AL13 AL14 AL27 AM9 AM11 AM13 AM14 AM16 AM18 B4 B16 B17 B18 C18 C20 D4 D14 D18 D20 D21 E1 E2 E4 E20 E29 E31 E32 F1 F2 F3 F4 F5 F7 F8 F9 F10 F11 F21 F22 F24 F25 F28 F29 F30 F31 F32 G1 G2 G3 G4 G7 G8 G9 G10 G11 G12 G13 G20 G21 G22 G25 G26 G27 G28 G29 H1 H2 H3 H4 H9 H10 H21 H27 H28 H31 J1 J2 J3 J4 J9 J10 J11 J13 J22 K2 K3 K4 K9 K10 K11 K14 K15 K20 K22 K29 L1 L2 L3 L9 L10 L11 L12 L13 L15 L18 L19 L22 M2 M3 M4 M5 M10 M11 M22 M23 M31 N1 N2 N3 N4 N11 N22 P1 P2 P3 P4 P7 P8 P11 P22 R1 R2 R3 R4 R7 R8 R11 R25 R26 T1 T2 T11 T31 T32 U5 U6 U22 U27 U28 V1 V2 V3 V4 V5 V6 V7 V8 V9 V10 V22 V25 V26 W5 W6 W7 W8 W9 W10 W11 W12 W21 W22 Y5 Y6 Y7 Y8 Y9 Y10 Y11 Y12 Y21 Y22; U18 5 7; U19 1 11; U20 1 11; U21 1 11; U22 1; U23 1; U24 1; U27 13 26 38 39 67 68; U29 3 4 7 18 19 20 24 30 57 63 64 74 76 77; U30 3 4 7 18 19 20 24 30 57 63 64 74 76 77; U32 5 7; U34 23; U39 1; U44 6 10; U45 6; U46 1 4; U47 1 4; U52 1 3 5 8 11 13 16 19 21; U53 1; XU2 6 15 19 27 36 45 46 55 68 83 92 102 104 113 126 135 147 156 165 203 212 224 233; Y4 2 5

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3.3V: length 13.3
  BOTTOM w0.508: 15.88,168.91 15.59,168.62 PMCJN1.19 ; 28.58,168.91 28.59,168.9 PMCJN1.45 ; PMCJN1.31 21.59,168.27 22.23,168.91 ; PMCJN1.41 26.59,168.36 26.03,168.91 ; 34.92,168.91 34.59,168.57 PMCJN1.57
5VM: length 15.9
  BOTTOM w0.508: PMCJN1.8 9.59,160.08 9.52,160.02 ; 19.69,160.02 20.59,160.92 PMCJN1.30 ; 29.84,160.02 30.59,160.76 30.59,162.51 PMCJN1.50 ; 14.61,160.02 14.59,160.04 PMCJN1.18 ; 36.2,160.02 36.59,160.41 PMCJN1.62 ; 24.77,160.02 24.59,160.2 PMCJN1.38
12VM: length 130.4
  BOTTOM w0.635: 3.31,152.41 2.54,151.64 2.54,124.84 4.06,123.32 7.75,123.32 8.51,124.08 11.56,124.08 13.46,122.17 ; 3.31,152.41 PMCJN2.1 6.6,152.39 6.6,150.5 ; 3.31,152.41 3.31,169.93 2.92,170.32 2.92,175.89 3.31,176.28 3.31,199.14 8.38,204.22 27.69,204.22 35.56,212.09
-12VM: length 3.5
  BOTTOM w0.508: PMCJN1.2 6.59,162.51 6.59,164.2 6.86,164.47 8.25,164.47
GND_HSSI: length 7.7
  L14_GND3 w0.094: 244.22,122.81 244.22,123.19 ; 252.98,126.16 252.91,126.24 ; 241.81,122.68 241.94,122.81
  L14_GND3 w0.127: 226.69,230.5 226.69,229.9 ; 255.27,224.41 255.27,224.28 254.89,223.9 ; 221.36,230.5 221.36,230.12 221.61,229.87 ; 271.15,231.27 271.15,230.5 ; 257.89,210.31 257.56,210.31 256.79,211.07 ; 227.71,231.39 227.33,231.01 ; 229.74,230.63 229.23,230.12 ; 232.13,230.5 231.47,230.5 ; 224.16,230.76 224.16,229.87
GND_PLL: length 0.7
  L17_PWR3 w0.094: 221.87,204.47 222.38,204.47
  L17_PWR3 w0.635: 201.68,187.83 201.8,187.71
NET_9_I26_1: length 3.9
  BOTTOM w0.127: 8.25,146.05 6.98,146.05 6.59,146.45 6.59,148.51 PMCJN2.2
PMC_AD<0>: length 4
  BOTTOM w0.127: PMCJN1.61 36.59,168.42 36.7,168.53 36.7,169.67 36.2,170.18
PMC_AD<1>: length 4.2
  BOTTOM w0.127: PMCJN1.60 35.56,162.51 35.43,162.38 35.43,159.51 36.2,158.75
PMC_AD<2>: length 2.8
  BOTTOM w0.127: PMCJN1.59 35.59,168.3 36.2,168.91
PMC_AD<3>: length 2.6
  BOTTOM w0.127: PMCJN1.58 34.59,160.36 34.92,160.02
PMC_AD<4>: length 2.5
  BOTTOM w0.127: 33.66,168.91 33.59,168.84 PMCJN1.55
PMC_AD<9>: length 4.2
  BOTTOM w0.127: 31.12,170.18 30.35,169.42 30.35,168.2 30.59,167.96 PMCJN1.49
PMC_AD<11>: length 4.2
  BOTTOM w0.127: 29.84,158.75 29.15,159.45 29.15,160.34 29.59,160.78 29.59,162.51 PMCJN1.48
PMC_AD<13>: length 4.1
  BOTTOM w0.127: 28.58,144.78 29.08,145.29 29.08,146.69 28.72,147.05 28.72,147.07 28.59,147.19 28.59,148.51 PMCJN2.46
PMC_AD<15>: length 2.5
  BOTTOM w0.127: 28.58,160.02 28.59,160.03 28.59,162.51 PMCJN1.46
PMC_AD<19>: length 2.7
  BOTTOM w0.127: 20.95,168.91 20.59,168.54 PMCJN1.29
PMC_AD<20>: length 2.5
  BOTTOM w0.127: 19.69,146.05 19.59,146.15 19.59,148.51 PMCJN2.28
PMC_AD<22>: length 2.5
  BOTTOM w0.127: 19.69,168.91 19.59,168.81 19.59,166.41 PMCJN1.27
PMC_AD<29>: length 2.6
  BOTTOM w0.127: 15.88,146.05 15.59,146.34 PMCJN2.20
PMC_BUSMODEN<1>: length 4.3
  BOTTOM w0.127: PMCJN1.7 9.59,167.96 10.16,168.53 10.16,169.54 9.52,170.18
PMC_DEVSELN: length 2.8
  BOTTOM w0.127: PMCJN1.37 24.59,168.23 25.12,168.76 25.12,168.96
PMC_FRAMEN: length 4.1
  BOTTOM w0.127: 23.49,170.18 22.92,169.61 22.92,168.62 22.86,168.56 22.86,168.4 22.59,168.13 PMCJN1.33
PMC_IRDYN: length 2.5
  BOTTOM w0.127: PMCJN1.36 23.59,160.11 23.49,160.02
PMC_LOCKN: length 2.7
  BOTTOM w0.127: PMCJN1.40 25.59,160.47 26.03,160.02

## Copper pours and planes (outline as drawn)
1.5V_A_INT on TOP (solid shape): 266.06,25.53 266.06,21.59 265.43,20.95 247.01,20.95 246.38,21.59 246.38,25.4 247.01,26.03 265.56,26.03
1.5V_A_INT on BOTTOM (solid shape): 250.19,41.91 250.82,41.27 250.82,41.24 253.97,41.24 255.91,43.18 263.53,43.18 264.16,42.55 264.16,38.73 263.53,38.1 259.72,38.1 258.44,36.83 258.44,22.23 255.27,19.05 255.27,15.24 254.63,14.61 245.11,14.61 244.47,15.24 244.47,19.05 241.3,22.23 241.3,40.64 241.9,41.24 248.89,41.24 249.56,41.91 249.56,45.09 250.19,45.09
1.5V_ENABLE on BOTTOM (solid shape): 157.48,202.82 157.48,201.55 156.84,200.91 151.13,200.91 150.5,201.55 150.5,202.95 151,203.45 156.84,203.45
1.5V_GX_INT on BOTTOM (solid shape): 99.06,290.83 99.06,285.75 97.79,284.48 90.8,284.48 89.53,285.75 89.53,288.93 88.9,289.56 87.12,289.56 86.49,290.2 86.49,291.47 87.12,292.1 97.79,292.1
1.5V_GX_INT on BOTTOM (solid shape): outline of 432 points within 234.57,132.72 266.06,142.88
1.5V_GX_INT on L6_IS3 (solid shape): outline of 1876 points within 249.56,102.87 269.24,143.51
1.5V_GX_INT on L11_PWR2 (solid shape): outline of 5925 points within 89.09,100.52 271.59,291.27
1.5V_OUT on TOP (solid shape): 101.6,300.99 101.6,295.28 100.96,294.64 100.96,288.29 101.6,287.66 114.3,287.66 114.93,288.29 114.93,294.64 114.3,295.28 114.3,300.99 114.93,301.62 118.74,301.62 119.38,300.99 119.38,293.37 116.84,290.83 116.84,286.39 114.93,284.48 100.33,284.48 98.42,286.39 98.42,291.47 96.52,293.37 96.52,300.99 97.16,301.62 100.96,301.62
1.5V_OUT on TOP (solid shape): 150.5,230.12 150.5,222.5 151.76,221.23 154.94,221.23 155.57,220.6 155.57,215.52 154.94,214.88 151.76,214.88 151.13,214.25 151.13,211.2 149.22,209.3 149.22,207.01 148.84,206.63 147.07,206.63 146.69,207.01 146.69,209.3 146.3,209.68 146.3,216.53 145.41,217.42 142.75,217.42 142.24,217.93 142.24,230.76 149.86,230.76
1.5V_OUT on L3_IS1 (solid shape): outline of 8333 points within 94.61,208.91 157.48,302.26
1.5V_PLL on BOTTOM (solid shape): 239.39,45.72 239.39,40.01 238.76,39.37 227.97,39.37 227.33,40.01 227.33,45.72 227.97,46.36 238.76,46.36
1.5V_PLL on L17_PWR3 (solid shape): outline of 3802 points within 0.64,0.64 268.03,236.41
1.5V_PLL_B on TOP (solid shape): 255.91,17.91 255.91,14.61 260.73,9.78 260.73,5.46 257.43,2.16 253.11,2.16 244.47,10.79 234.31,10.79 233.04,12.06 233.04,18.41 234.31,19.69 254.13,19.69
1.5V_PLL_B on BOTTOM (solid shape): 240.03,36.83 240.03,21.59 243.2,18.41 243.2,15.24 242.57,14.61 236.85,14.61 227.33,24.13 227.33,36.83 227.97,37.46 239.39,37.46
1.5V_S_INT on BOTTOM (solid shape): 129.41,291.21 129.41,290.2 128.78,289.56 127,289.56 126.36,288.93 126.36,285.75 127,285.12 129.54,285.12 130.18,284.48 130.18,281.94 129.54,281.31 125.48,281.31 122.3,284.48 117.47,284.48 116.2,285.75 116.2,290.2 117.86,291.85 128.78,291.85
1.5V_S_INT on L5_PWR1 (solid shape): outline of 239 points within 102.55,103.31 170.5,291.78
1.5V_VCCG on L10_IS6 (solid shape): outline of 1022 points within 239.53,215.26 266.7,226.69
1.5V_VCCG on L17_PWR3 (solid shape): 246.19,216.08 246.19,213.69 246.05,213.55 239.44,213.55 238.55,212.66 229.95,212.66 229.81,212.8 229.81,214.95 229.87,214.95 229.94,214.96 230,215 230.44,215.44 230.44,216.2 230.46,216.22 246.05,216.22
1.5V_VCCP on BOTTOM (solid shape): 239.71,225.42 239.2,224.92 237.62,224.92 237.55,224.98 237.55,225.74 238.12,226.31 238.12,227.65 239.71,227.65
1.5V_VCCP on L5_PWR1 (solid shape): 239.99,226.5 240.01,226.48 240.03,226.47 240.06,226.44 240.16,226.34 240.16,225.6 239.47,224.92 238.96,224.92 238.63,224.59 238.63,221.19 238.51,221.04 238.47,220.85 238.6,220.55 238.92,220.43 239.23,220.43 239.45,220.22 239.45,219.89 239.45,219.83 239.45,213.87 239.56,213.55 239.88,213.44 240.16,213.44 240.36,213.23 245.34,213.23 245.44,213.13 245.44,211.85 244.84,211.25 244.82,211.25 229.89,211.25 229.26,211.88 229.26,213.13 229.36,213.23 236.27,213.23 236.35,213.23 238.3,213.23 238.63,213.56 238.63,218.24 238.25,218.62 238.25,218.74 238.26,218.79 238.27,218.85 238.26,218.9 238.25,218.95 238.25,219.82 238.25,219.88 238.25,220.03 238.03,220.26 237.89,220.26 237.24,220.91 237.24,222.96 237.49,223.21 237.49,226.43 237.57,226.5
1.5V_XCVR on TOP (solid shape): 268.61,17.91 268.61,14.61 273.43,9.78 273.43,5.46 270.13,2.16 265.81,2.16 262.51,5.46 262.51,11.05 259.72,13.84 259.72,18.67 260.73,19.69 266.83,19.69
1.5V_XCVR on BOTTOM (solid shape): 245.11,230.76 245.11,230.25 244.22,229.36 244.22,228.73 243.97,228.47 231.65,228.47 231.65,229.87 232.28,230.5 242.32,230.5 242.95,231.14 244.73,231.14
1.5V_XCVR on BOTTOM (solid shape): 264.29,36.07 264.29,32.26 265.68,30.86 267.21,30.86 267.97,30.1 267.97,19.69 273.43,14.22 273.43,5.46 270.13,2.16 265.81,2.16 262.51,5.46 262.51,11.3 259.72,14.1 259.72,36.2 260.35,36.83 263.53,36.83
1.5V_XCVR on L5_PWR1 (solid shape): outline of 1497 points within 195.14,28.26 279.08,249.05
1.5V_XCVR1 on BOTTOM (solid shape): 243.97,226.57 244.54,226 244.54,225.68 244.86,225.36 244.86,224.92 244.09,224.92 243.97,224.79 243.97,224.03 243.71,223.77 242.38,223.77 242.19,223.96 241.74,223.96 241.62,224.09 241.62,224.41 241.74,224.54 242.38,224.54 242.44,224.6 243.33,224.6 243.46,224.73 243.46,225.68 243.33,225.81 242.7,225.81 242.44,226.06 242.44,227.71 243.97,227.71
1.5V_XCVR1 on L5_PWR1 (solid shape): 245.05,225.92 244.95,225.72 244.91,225.5 245.15,224.98 245.71,224.83 245.88,224.83 245.9,224.81 245.9,224.37 245.87,224.35 245.79,224.35 245.74,224.35 245.69,224.35 245.14,223.8 245.69,223.25 245.74,223.25 245.79,223.25 245.9,223.25 245.94,223.21 245.94,222.22 245.8,222.05 245.75,221.84 245.77,221.73 245.81,221.62 245.55,221.37 245.55,219.24 245.45,219.14 245.45,219.13 245.44,219.11 245.44,213.57 245.36,213.49 242.53,213.49 242.44,213.58 242.44,215.57 242.27,215.75 242.27,221.07 242.05,221.28 241.7,221.28 241.68,221.3 241.66,221.31 241.43,221.54 241.43,224.5 241.64,224.5 241.66,224.51 241.73,224.5 241.81,224.49 242.2,224.65 242.36,225.04 242.35,225.16 242.32,225.27 242.32,226.34 242.48,226.5 244.47,226.5
1.5V_XCVR2 on BOTTOM (solid shape): 241.81,226.57 241.3,226.06 241.3,223.77 241.05,223.52 239.52,223.52 238.57,222.57 237.55,222.57 237.49,222.63 237.49,223.2 238.89,224.6 239.39,224.6 240.03,225.23 240.03,227.46 240.22,227.65 241.81,227.65
1.5V_XCVR2 on L5_PWR1 (solid shape): 241.3,225.27 241.27,225.16 241.25,225.04 241.26,224.94 241.29,224.84 241.17,224.72 241.17,221.44 241.45,221.16 241.45,215.64 241.65,215.44 242.02,215.44 242.19,215.28 242.19,213.58 242.1,213.49 240.46,213.49 240.26,213.69 240.26,213.81 240.26,213.87 240.26,219.83 240.15,220.14 239.85,220.27 239.82,220.27 239.78,220.26 239.29,220.75 239.3,220.8 239.31,220.85 239.18,221.15 238.89,221.27 238.89,224.48 239.07,224.66 239.57,224.66 240.41,225.5 240.41,226.32 240.59,226.5 241.3,226.5
1.5V_XCVR3 on BOTTOM (solid shape): 235.33,226.31 235.08,226.06 235.08,225.17 234.76,224.85 232.47,224.85 232.41,224.92 232.41,225.3 232.57,225.46 232.7,225.46 233.81,226.57 233.81,227.65 235.33,227.65
1.5V_XCVR3 on L5_PWR1 (solid shape): 234.7,226.39 234.7,223.45 234.19,222.94 234.19,220.42 234.44,220.17 234.44,219.07 234.44,219.01 234.44,218.85 234.57,218.55 234.88,218.44 235,218.44 235.02,218.44 235.42,218.05 235.43,218.03 235.45,218.01 235.45,217.89 235.56,217.57 235.88,217.45 236.01,217.45 236.44,217.03 236.44,216.98 236.45,216.96 236.45,216.84 236.45,215.88 236.45,215.82 236.45,215.67 236.22,215.44 236.22,213.54 236.17,213.49 234.49,213.49 234.44,213.54 234.44,215.85 234.02,216.27 232.6,216.27 232.26,216.61 232.26,216.81 232.26,216.87 232.26,218.82 232.26,218.85 232.16,219.12 231.9,219.25 231.9,226.5 234.58,226.5
1.5V_XCVR4 on BOTTOM (solid shape): 233.17,226.69 232.09,225.62 232.09,223.52 231.27,222.69 231.27,220.73 231.14,220.6 229.95,220.6 229.62,220.93 229.62,223.01 229.74,223.14 229.74,223.32 230.4,223.98 230.4,225.81 230.15,226.06 229.74,226.06 229.36,226.44 229.36,226.82 229.49,226.95 230.89,226.95 231.58,227.65 233.17,227.65
1.5V_XCVR4 on L5_PWR1 (solid shape): 230.75,226.5 231.65,226.5 231.65,219.2 231.5,219.05 231.44,218.85 231.45,218.79 231.44,218.76 231.44,216.87 231.51,216.62 231.71,216.46 231.79,216.44 231.85,216.43 231.9,216.44 231.96,216.45 232.07,216.45 232.42,216.09 232.44,216.07 232.44,215.68 232.67,215.44 232.82,215.44 232.88,215.44 233.83,215.44 233.89,215.44 234.08,215.44 234.19,215.34 234.19,213.54 234.14,213.49 229.36,213.49 229.26,213.59 229.26,220.64 229.26,220.65 229.26,226.78 229.49,227.01 230.25,227.01
1.5V_XCVR5 on BOTTOM (solid shape): 237.49,226.06 237.24,225.81 237.24,224.35 236.98,224.09 236.6,224.09 236.47,224.22 236.47,224.73 236.35,224.85 235.78,224.85 235.59,225.04 235.59,226.06 235.97,226.44 235.97,227.65 237.49,227.65
1.5V_XCVR5 on L5_PWR1 (solid shape): 237.24,226.44 237.24,223.32 236.98,223.06 236.98,220.8 237.44,220.34 237.44,220.33 237.44,219.88 237.44,219.82 237.44,218.92 237.44,218.89 237.45,218.87 237.45,218.85 237.55,218.58 237.79,218.44 237.79,218.44 237.89,218.44 238.07,218.44 238.38,218.13 238.38,213.67 238.2,213.49 236.55,213.49 236.47,213.57 236.47,215.34 236.58,215.44 236.82,215.44 236.89,215.44 237.01,215.44 237.07,215.5 237.22,215.66 237.26,215.88 237.26,216.84 237.14,217.15 236.82,217.27 236.55,217.27 236.25,217.58 236.25,217.75 236.26,217.8 236.26,217.86 236.14,218.14 235.85,218.26 235.81,218.26 235.78,218.26 235.74,218.26 235.56,218.26 235.25,218.57 235.25,218.58 235.25,218.82 235.18,219.08 234.95,219.24 234.95,220.02 234.44,220.52 234.44,222.83 234.95,223.34 234.95,226.39 235.07,226.5 237.17,226.5
1.25V on TOP (solid shape): 209.17,222.38 209.17,221.23 209.42,220.98 210.44,220.98 210.44,217.68 209.55,217.68 209.55,219.2 209.3,219.46 208.53,219.46 208.41,219.58 208.41,222.38 208.53,222.5 209.04,222.5
1.25V on TOP (solid shape): outline of 227 points within 159.38,244.35 178.44,259.08
1.25V on BOTTOM (solid shape): 178.56,240.16 178.56,235.97 178.31,235.71 175.51,235.71 174.88,236.35 174.88,239.78 175.51,240.41 178.31,240.41
1.25V on BOTTOM (solid shape): 178.56,223.77 178.56,219.58 178.31,219.33 175.51,219.33 174.88,219.96 174.88,223.39 175.51,224.03 178.31,224.03
1.25V on BOTTOM (solid shape): 178.56,213.61 178.56,209.42 178.31,209.17 175.51,209.17 174.88,209.8 174.88,213.23 175.51,213.87 178.31,213.87
1.25V on BOTTOM (solid shape): 178.56,184.28 178.56,180.09 178.31,179.83 175.51,179.83 174.88,180.47 174.88,183.9 175.51,184.53 178.31,184.53
1.25V on BOTTOM (solid shape): 178.56,167.77 178.56,163.58 178.31,163.32 175.51,163.32 174.88,163.96 174.88,167.39 175.51,168.02 178.31,168.02
1.25V on BOTTOM (solid shape): 178.69,250.44 178.69,246.25 178.44,246 175.64,246 175.01,246.63 175.01,250.06 175.64,250.7 178.44,250.7
1.25V on BOTTOM (solid shape): 178.69,156.34 178.69,152.15 178.44,151.89 175.64,151.89 175.01,152.53 175.01,155.96 175.64,156.59 178.44,156.59
1.25V on BOTTOM (solid shape): 178.69,194.56 178.69,191.13 177.55,191.13 177.55,190.37 177.29,190.12 175.64,190.12 175.01,190.75 175.01,194.18 175.64,194.82 178.44,194.82
1.25V on BOTTOM (solid shape): 178.56,142.49 178.56,138.3 178.31,138.05 176.91,138.05 176.66,138.3 176.66,138.81 176.4,139.06 174.88,139.06 174.88,142.11 175.51,142.75 178.31,142.75
1.25V on BOTTOM (solid shape): 178.94,148.21 178.94,144.02 178.69,143.76 177.93,143.76 177.55,144.14 176.66,144.14 176.28,144.53 174.75,144.53 174.75,147.57 176.28,147.57 176.66,147.95 177.29,147.95 177.8,148.46 178.69,148.46
1.25V on BOTTOM (solid shape): 178.31,176.02 178.69,176.02 178.69,172.72 177.55,172.72 177.55,171.83 177.67,171.7 177.67,168.91 177.29,168.53 176.53,168.53 175.77,169.29 174.88,169.29 174.88,176.15 175.89,176.15 176.66,176.91 177.42,176.91
1.25V on L5_PWR1 (solid shape): outline of 1859 points within 164.72,134.24 210.5,261.37
1.25V_GX_SSTL_VREF on TOP (solid shape): 148.59,272.42 148.59,270.38 147.45,269.24 147.45,264.03 147.95,263.53 151.13,263.53 151.89,262.76 151.89,258.57 151.64,258.32 147.32,258.32 146.43,259.21 146.43,272.16 147.07,272.8 148.21,272.8
1.25V_GX_SSTL_VREF on BOTTOM (solid shape): 234.44,202.39 234.44,198.42 234.26,198.25 233.43,198.25 233.25,198.42 233.25,202.39 233.43,202.56 234.26,202.56
1.25V_GX_SSTL_VREF on L4_IS2 (solid shape): outline of 7451 points within 124.46,205.1 235.61,271.4
1.25V_GX_SSTL_VREF on L15_IS9 (solid shape): outline of 392 points within 233.25,200.25 235.43,207.44
2.5V on TOP (solid shape): outline of 295 points within 152.27,251.59 175.26,285.88
2.5V on BOTTOM (solid shape): 160.02,287.66 160.02,280.67 159.38,280.04 154.31,280.04 153.67,280.67 153.67,283.21 152.4,284.48 152.4,287.91 152.78,288.29 159.38,288.29
2.5V_DDR_VDD on L17_PWR3 (solid shape): outline of 141 points within 143.32,132.91 195.77,255.46
2.5V_ENABLE on BOTTOM (solid shape): 156.21,270.26 157.35,269.11 159.45,269.11 159.45,264.16 154.56,264.16 154.05,264.67 152.27,264.67 151.76,265.18 151.76,266.06 155.45,266.06 155.45,268.1 153.42,268.1 153.42,266.06 151.76,266.06 151.76,269.88 153.03,271.15 156.21,271.15
2.5V_GX_IO on BOTTOM (solid shape): 151.76,287.66 151.76,284.1 153.03,282.83 153.03,280.54 152.53,280.04 149.22,280.04 146.69,282.58 146.69,283.97 148.48,283.97 148.48,283.94 148.48,283.88 148.5,283.82 148.52,283.76 148.56,283.7 148.59,283.65 148.64,283.6 148.69,283.57 148.74,283.53 148.8,283.51 148.86,283.49 148.92,283.48 148.99,283.48 149.05,283.48 149.11,283.5 149.17,283.52 149.23,283.55 149.28,283.58 149.33,283.63 149.37,283.68 149.4,283.73 149.43,283.79 149.45,283.85 149.46,283.91 149.47,283.97 149.46,284.04 149.45,284.1 149.43,284.16 149.4,284.22 149.37,284.27 149.33,284.32 149.28,284.36 149.23,284.4 149.17,284.43 149.11,284.45 149.05,284.46 148.99,284.47 148.92,284.47 148.86,284.46 148.8,284.44 148.74,284.41 148.69,284.38 148.64,284.34 148.59,284.29 148.56,284.24 148.52,284.19 148.5,284.13 148.48,284.07 148.48,284 148.48,283.97 146.69,283.97 146.69,287.66 147.32,288.29 151.13,288.29
2.5V_GX_IO on L17_PWR3 (solid shape): outline of 1180 points within 0.64,135.57 238.82,304.16
2.5V_OUT on TOP (solid shape): 156.21,290.83 158.11,290.83 158.11,287.02 146.05,287.02 146.05,290.83 147.95,290.83 150.5,293.37 153.67,293.37
2.5V_OUT on BOTTOM (solid shape): outline of 134 points within 148.59,264.16 174.62,293.37
2.5V_REG_IN on BOTTOM (solid shape): 159.51,274.32 161.35,274.32 161.35,264.16 160.08,264.16 160.08,269.88 157.48,269.88 156.84,270.51 156.84,271.15 156.21,271.78 154.31,271.78 153.54,272.54 153.54,275.34 154.18,275.97 157.86,275.97
3.3V on TOP (solid shape): 51.18,45.21 51.18,41.15 51.05,41.02 48.77,41.02 48.64,41.15 48.64,45.21 48.77,45.34 51.05,45.34
3.3V on TOP (solid shape): 107.31,135.64 107.31,131.06 107.06,130.81 103.76,130.81 103.5,131.06 103.5,135.64 103.76,135.89 107.06,135.89
3.3V on TOP (solid shape): 94.61,252.48 94.61,250.19 94.49,250.06 93.6,250.06 90.17,246.63 90.17,241.3 89.53,240.66 88.9,240.66 88.39,241.17 88.39,252.22 89.03,252.86 94.23,252.86
3.3V on TOP (solid shape): 271.65,202.44 271.65,201.42 271.53,201.29 270.51,201.29 270.13,200.91 270.13,199.77 270,199.64 268.35,199.64 268.22,199.77 268.22,201.42 267.97,201.68 265.94,201.68 265.94,202.69 271.4,202.69
3.3V on TOP (solid shape): 46.74,112.14 46.74,111.38 46.48,111.12 46.48,107.82 46.36,107.7 42.55,107.7 42.42,107.82 42.42,110.74 42.04,111.12 41.78,111.12 41.53,111.38 41.53,112.01 41.78,112.27 46.61,112.27
3.3V on BOTTOM (solid shape): 117.73,19.69 117.73,17.65 117.6,17.53 113.54,17.53 113.41,17.65 113.41,19.69 113.54,19.81 117.6,19.81
3.3V on BOTTOM (solid shape): 124.08,22.99 124.08,20.95 123.95,20.83 119.89,20.83 119.76,20.95 119.76,22.99 119.89,23.11 123.95,23.11
3.3V on BOTTOM (solid shape): 110.11,19.69 110.11,17.65 109.98,17.53 108.46,17.53 108.33,17.65 108.33,18.03 109.09,18.8 109.09,19.81 109.98,19.81
3.3V on L5_PWR1 (solid shape): outline of 190619 points within 0.64,0.64 329.56,304.16
3.3V_CLK1 on TOP (solid shape): 179.96,134.24 179.96,133.48 179.07,132.59 177.42,132.59 176.53,133.48 176.53,135.13 177.04,135.64 178.56,135.64
3.3V_CLK1 on TOP (solid shape): outline of 652 points within 170.18,41.27 205.74,68.58
3.3V_CLK1 on L15_IS9 (solid shape): outline of 1566 points within 170.18,41.27 205.74,68.58
3.3V_CLK2 on TOP (solid shape): outline of 436 points within 172.85,85.6 203.2,108.58
3.3V_CLK2 on L15_IS9 (solid shape): outline of 611 points within 172.72,85.09 189.23,101.35
3.3V_DIV on L5_PWR1 (solid shape): 173.23,224.43 173.23,195.3 171.98,194.06 162.41,194.06 160.78,195.69 160.78,196.14 160.84,196.14 160.85,196.14 161.53,196.6 160.85,197.06 160.84,197.05 160.78,197.05 160.78,202.96 160.84,202.96 161.4,203.45 160.84,203.94 160.78,203.94 160.78,208 157.73,211.05 157.73,215.76 157.83,215.76 157.83,215.72 159.6,215.87 157.83,216.03 157.83,215.99 157.73,215.99 157.73,222.76 157.73,223.65 157.99,223.9 158.03,223.86 158.03,223.85 158.85,223.68 158.68,224.49 158.67,224.49 158.62,224.54 159.51,225.42 172.23,225.42
3.3V_ENABLE on TOP (solid shape): 50.16,273.69 50.16,265.43 49.97,265.24 45.34,265.24 45.34,271.15 44.7,271.78 36.2,271.78 26.67,262.25 26.67,257.18 26.03,256.54 24.13,256.54 23.49,257.18 23.49,265.43 34.29,276.23 47.62,276.23
3.3V_EXT_CLK on L5_PWR1 (solid shape): 145.8,186.58 145.8,169.65 136.7,160.55 132.4,164.85 132.4,187.71 144.67,187.71
3.3V_FAN_OUT on TOP (solid shape): 120.27,277.75 125.35,277.75 125.98,277.11 125.98,273.94 126.62,273.3 129.67,273.3 131.57,271.4 133.86,271.4 134.24,271.02 134.24,269.24 133.86,268.86 131.57,268.86 131.19,268.48 124.46,268.48 123.44,267.46 123.44,263.02 121.28,260.86 118.11,260.86 109.09,251.84 109.09,248.28 108.46,247.65 102.74,247.65 102.23,248.16 102.23,255.27 103,256.03 106.55,256.03 107.95,257.43 107.95,262.25 107.31,262.89 102.74,262.89 102.23,263.4 102.23,270.76 102.74,271.27 106.55,271.27 107.95,272.67 107.95,277.5 107.31,278.13 102.74,278.13 102.23,278.64 102.23,283.21 102.87,283.85 114.17,283.85
3.3V_GX_IO on TOP (solid shape): 94.61,282.96 94.61,280.67 94.49,280.54 93.6,280.54 90.17,277.11 90.17,274.07 89.79,273.69 88.77,273.69 88.39,274.07 88.39,282.7 89.03,283.34 94.23,283.34
3.3V_GX_IO on L11_PWR2 (solid shape): outline of 89532 points within 61.15,0.64 329.56,304.16
3.3V_GX_IO on L15_IS9 (solid shape): outline of 4777 points within 238.25,199.26 250.44,215.44
3.3V_GX_XCVR_AND_CLOCKS on TOP (solid shape): 50.29,259.91 44.89,259.91 44.58,259.59 44.58,256.16 44.83,255.91 44.83,249.56 44.2,248.92 40.77,248.92 40.13,249.56 40.13,255.27 39.5,255.91 34.92,255.91 34.29,256.54 34.29,260.35 34.99,261.05 50.29,261.05
3.3V_LAN on TOP (solid shape): 44.07,122.68 44.45,122.68 44.45,120.27 40.01,120.27 39.75,120.52 39.75,122.68 39.88,122.81 43.94,122.81
3.3V_LAN on L5_PWR1 (solid shape): outline of 356 points within 0.64,115.19 51.82,143.38
3.3V_PLL on L4_IS2 (solid shape): outline of 13184 points within 112.39,129.16 156.21,161.04
3.3V_PS on TOP (solid shape): 150.11,253.62 150.11,249.17 149.86,248.92 146.69,248.92 146.3,248.54 138.43,248.54 138.05,248.92 136.78,248.92 136.4,248.54 135.25,248.54 135,248.79 135,252.98 135.13,253.11 140.21,253.11 141.1,254 141.1,255.4 141.86,256.16 147.57,256.16
3.3V_PS on BOTTOM (solid shape): 149.48,259.97 149.48,254.25 150.75,252.98 150.75,250.44 150.11,249.81 143.13,249.81 142.49,250.44 142.49,259.97 143.13,260.6 148.84,260.6
3.3V_RS232 on L5_PWR1 (solid shape): 28.57,66.32 28.57,56.54 29.84,55.27 29.84,53.06 28.45,51.67 28.45,38.23 23.73,38.23 19.3,42.65 19.3,70.38 20.43,71.5 23.39,71.5
3.3V_S_IO on TOP (solid shape): 94.61,267.72 94.61,265.43 94.49,265.3 93.6,265.3 90.17,261.87 90.17,258.83 89.79,258.44 88.77,258.44 88.39,258.83 88.39,267.46 89.03,268.1 94.23,268.1
3.3V_S_IO on L11_PWR2 (solid shape): outline of 1650 points within 0.64,0.64 168.72,304.16
3.3V_S_IOB on TOP (solid shape): 102.74,261.75 107.06,261.75 107.06,257.43 106.3,256.67 102.49,256.67 101.6,255.78 101.6,254.63 101.09,254.13 93.6,254.13 90.68,257.05 90.68,261.62 93.85,264.8 99.69,264.8
3.3V_S_IOB on BOTTOM (solid shape): 101.47,261.49 101.47,257.05 98.55,254.13 93.34,254.13 90.55,256.92 90.55,261.62 91.19,262.25 91.19,268.1 94.87,268.1
3.3V_SOURCE on TOP (solid shape): 134.75,259.59 134.75,256.54 135,256.29 136.02,256.29 136.27,256.54 136.27,258.57 136.4,258.7 139.95,258.7 140.59,258.06 140.59,254.25 139.95,253.62 133.6,253.62 126.87,254.88 123.09,249.17 123.21,247.95 123.57,246.78 123.57,245.62 122.94,244.98 110.74,244.98 109.98,245.75 109.98,251.46 118.62,260.1 134.24,260.1
3.3V_TEL on TOP (solid shape): 49.91,205.99 49.91,204.47 44.2,198.75 38.61,198.75 38.61,202.56 43.31,202.56 45.47,204.72 45.47,205.36 47.12,207.01 48.9,207.01
3.3V_TEL on BOTTOM (solid shape): 56.13,213.49 56.13,190.63 55.5,189.99 54.23,189.99 53.59,190.63 53.59,202.06 52.96,202.69 38.35,202.69 37.72,203.33 37.72,213.49 38.35,214.12 55.5,214.12
3.3V_XCVR_CLKS on TOP (solid shape): 68.2,252.73 68.2,247.01 67.56,246.38 59.05,246.38 58.55,246.89 58.55,252.86 59.05,253.36 67.56,253.36
3.3V_XCVR_CLKS on L7_IS4 (solid shape): outline of 27347 points within 186.69,46.36 319.41,301.62
3.3V_XCVR_CLKS on L11_PWR2 (solid shape): outline of 68534 points within 43.37,0.64 269.68,254.44
3.3V_XCVR_CLKS_SOURCE on TOP (solid shape): outline of 117 points within 33.66,222 121.28,254.63
3.3V_XPAK on L4_IS2 (solid shape): outline of 530 points within 237.62,111.76 258.95,118.36
3.3VIO_ENABLE on BOTTOM (solid shape): 139.95,279.02 139.95,273.3 139.32,272.67 137.92,272.67 137.41,273.18 137.41,279.02 138.05,279.65 139.32,279.65
3.3VM on TOP (solid shape): 37.46,201.42 37.46,198.75 41.91,194.31 41.91,186.82 38.1,186.82 38.1,191.64 32.13,197.61 32.13,202.56 36.32,202.56
3.3VM on BOTTOM (solid shape): 44.07,201.42 44.07,193.04 43.43,192.41 34.92,192.41 34.35,192.98 34.35,198.75 34.99,199.39 37.46,199.39 38.1,200.03 38.1,201.42 38.73,202.06 43.43,202.06
3.3VM on BOTTOM (solid shape): 266.19,50.04 266.19,43.94 266.06,43.82 264.16,43.82 263.53,44.45 254.63,44.45 253.62,43.43 252.09,43.43 251.84,43.69 251.84,47.37 252.73,48.26 262.38,48.26 264.29,50.16 266.06,50.16
3.3VM on L4_IS2 (solid shape): outline of 37306 points within 0.63,0.63 264.16,289.56
3.3VM_ATX on TOP (solid shape): 35.56,191.13 35.56,186.06 31.75,186.06 31.12,185.42 29.84,185.42 29.21,186.06 29.21,189.23 31.75,191.77 34.92,191.77
3.3VM_ATX on BOTTOM (solid shape): 33.02,251.46 33.02,245.11 31.75,243.84 26.67,243.84 25.4,245.11 25.4,245.75 24.13,247.01 20.95,247.01 19.05,248.92 19.05,251.46 19.69,252.09 32.38,252.09
3.3VM_ATX on L3_IS1 (solid shape): outline of 457 points within 21.59,184.66 38.73,252.09
3.3VM_ATX on L6_IS3 (solid shape): outline of 2861 points within 18.41,185.42 36.2,252.09
5V_CF on L15_IS9 (solid shape): outline of 448 points within 10.16,95.25 21.59,104.14
5V_TEL on TOP (solid shape): 50.16,187.32 50.16,179.07 48.9,177.8 37.46,177.8 36.83,178.44 36.83,183.51 38.1,184.78 41.91,184.78 45.09,187.96 49.53,187.96
5V_TEL on BOTTOM (solid shape): 56.13,188.72 56.13,177.93 55.5,177.29 45.34,177.29 44.7,177.93 44.7,188.72 45.34,189.36 55.5,189.36
5V_XPAK on L4_IS2 (solid shape): outline of 21388 points within 14.61,24.13 262.89,171.45
5VM on TOP (solid shape): 35.56,175.89 34.92,175.26 32.38,175.26 31.75,175.89 31.75,182.88 35.56,182.88
5VM on TOP (solid shape): 44.58,270.38 44.58,264.6 50.29,264.6 50.29,263.33 40.64,263.33 40.13,263.84 40.13,270.64 40.64,271.15 43.82,271.15
5VM on TOP (solid shape): 42.93,236.6 42.93,226.57 42.29,225.93 38.48,225.93 37.85,226.57 37.85,236.6 38.48,237.24 42.29,237.24
5VM on BOTTOM (solid shape): 149.22,203.45 147.83,202.06 147.83,201.42 147.07,200.66 145.41,200.66 145.41,204.98 146.05,205.61 147.07,205.61 147.45,205.99 149.22,205.99
5VM on BOTTOM (solid shape): 283.85,100.33 281.94,98.42 276.23,98.42 273.05,95.25 263.53,95.25 262.25,96.52 262.25,102.87 263.53,104.14 267.34,104.14 272.42,109.22 283.85,109.22
5VM on BOTTOM (solid shape): 62.48,197.61 62.48,179.32 61.59,178.44 61.59,171.45 60.96,170.81 57.79,170.81 56.77,171.83 56.77,197.61 57.4,198.25 61.85,198.25
5VM on BOTTOM (solid shape): 138.81,270 139.45,270 140.21,269.24 140.21,267.59 135.89,267.59 135.25,268.22 135.25,269.24 134.37,270.13 134.37,271.15 134.62,271.4 137.41,271.4
5VM on L7_IS4 (solid shape): outline of 43901 points within 1.27,58.42 161.29,290.83
5VM on L10_IS6 (solid shape): outline of 9479 points within 69.22,41.91 268.61,114.93
5VM_ATX on TOP (solid shape): 36.83,238.12 36.83,226.69 36.2,226.06 27.94,226.06 27.3,226.69 27.3,230.5 27.94,231.14 29.84,231.14 30.48,231.78 30.48,233.68 29.84,234.31 27.94,234.31 27.3,234.95 27.3,238.25 27.94,238.89 36.07,238.89
5VM_ATX on BOTTOM (solid shape): outline of 815 points within 20.32,209.55 31.75,238.76
12V_TEL on TOP (solid shape): 49.53,220.34 49.53,214 48.9,213.36 40.01,213.36 38.73,214.63 38.73,218.44 40.01,219.71 43.18,219.71 44.45,220.98 48.9,220.98
12V_TEL on BOTTOM (solid shape): 55.5,224.28 55.5,216.03 54.86,215.39 43.43,215.39 42.8,216.03 42.8,222.88 43.32,222.88 43.32,222.85 43.33,222.79 43.34,222.73 43.37,222.67 43.4,222.61 43.44,222.56 43.48,222.52 43.53,222.48 43.59,222.45 43.64,222.42 43.7,222.4 43.77,222.39 43.83,222.39 43.89,222.4 43.96,222.41 44.02,222.43 44.07,222.46 44.12,222.5 44.17,222.54 44.21,222.59 44.25,222.64 44.27,222.7 44.29,222.76 44.31,222.82 44.31,222.88 44.31,222.95 44.29,223.01 44.27,223.07 44.25,223.13 44.21,223.18 44.17,223.23 44.12,223.27 44.07,223.31 44.02,223.34 43.96,223.36 43.89,223.37 43.83,223.38 43.77,223.38 43.7,223.37 43.64,223.35 43.59,223.32 43.53,223.29 43.48,223.25 43.44,223.21 43.4,223.16 43.37,223.1 43.34,223.04 43.33,222.98 43.32,222.92 43.32,222.88 42.8,222.88 42.8,224.28 43.43,224.92 54.86,224.92
12VM on TOP (solid shape): 51.82,112.01 51.82,111.38 51.56,111.12 51.56,107.82 51.44,107.7 50.16,107.7 50.04,107.82 50.04,111.12 49.78,111.38 49.78,112.01 49.91,112.14 51.69,112.14
12VM on TOP (solid shape): 37.46,223.52 37.46,214.63 39.37,212.72 41.27,212.72 42.8,211.2 42.8,205.74 42.55,205.49 38.35,205.49 37.72,206.12 37.72,209.93 36.83,210.82 34.29,210.82 31.75,213.36 31.75,224.16 32.38,224.79 36.2,224.79
12VM_ATX on TOP (solid shape): 33.66,210.19 36.2,210.19 36.83,209.55 36.83,205.74 36.2,205.1 27.94,205.1 27.3,205.74 27.3,212.72 27.94,213.36 30.48,213.36
-48V_IN on TOP (solid shape): 121.28,205.74 121.28,200.28 117.6,196.6 110.11,196.6 105.41,201.29 105.41,207.01 106.04,207.64 119.38,207.64
-48V_IN on BOTTOM (solid shape): 123.19,204.72 123.19,201.04 118.74,196.6 112.01,196.6 111.76,196.34 106.43,196.34 105.79,196.98 105.79,204.47 108.97,207.64 120.27,207.64
-48V_PWR on TOP (solid shape): 110.49,213.36 110.49,209.55 109.85,208.91 106.04,208.91 103.5,206.38 103.5,203.2 102.87,202.56 95.25,202.56 94.61,203.2 94.61,214 95.25,214.63 109.22,214.63
-48V_PWR on BOTTOM (solid shape): 111.12,231.14 111.12,209.55 110.49,208.91 108.58,208.91 105.03,205.36 105.03,200.15 104.39,199.52 92.96,199.52 92.33,200.15 92.33,209.04 99.82,216.53 101.73,216.53 101.73,227.08 98.69,230.11 97.68,230.11 97.55,230.12 97.3,230.12 92.96,230.12 92.33,230.76 92.33,236.22 93.6,237.49 104.77,237.49
GND on TOP (solid shape): 88.01,261.62 88.01,258.95 87.5,258.44 86.36,258.44 85.72,259.08 85.72,261.62 86.36,262.25 87.38,262.25
GND on TOP (solid shape): 113.03,301.62 113.03,299.34 112.01,298.32 103.76,298.32 102.87,299.21 102.87,301.62 103.5,302.26 112.39,302.26
GND on TOP (solid shape): 144.4,87.88 144.4,85.6 144.27,85.47 140.21,85.47 140.08,85.6 140.08,87.88 140.21,88.01 144.27,88.01
GND on TOP (solid shape): 150.75,87.88 150.75,85.6 150.62,85.47 146.56,85.47 146.43,85.6 146.43,87.88 146.56,88.01 150.62,88.01
GND on TOP (solid shape): 162.18,87.88 162.18,85.6 162.05,85.47 157.99,85.47 157.86,85.6 157.86,87.88 157.99,88.01 162.05,88.01
GND on TOP (solid shape): 168.53,87.88 168.53,85.6 168.4,85.47 164.34,85.47 164.21,85.6 164.21,87.88 164.34,88.01 168.4,88.01
GND on TOP (solid shape): 88.01,246.38 88.01,241.55 87.5,241.05 84.84,241.05 84.2,241.68 84.2,244.86 86.36,247.01 87.38,247.01
GND on TOP (solid shape): 176.66,259.21 176.66,258.7 176.91,258.44 177.93,258.44 177.93,255.14 177.8,255.02 175.77,255.02 175.64,255.14 175.64,259.21 175.77,259.33 176.53,259.33
GND on TOP (solid shape): 39.37,262.89 38.73,262.25 34.29,262.25 33.02,260.99 33.02,257.81 32.19,256.98 27.56,256.98 27.56,258.7 27.94,259.08 27.94,262.25 36.83,271.15 39.37,271.15
GND on TOP (solid shape): 170.81,264.8 170.81,260.99 170.18,260.35 160.02,260.35 159.38,259.72 154.31,259.72 153.03,260.99 153.03,264.67 153.8,265.43 165.1,265.43 165.73,266.06 169.54,266.06
GND on TOP (solid shape): 69.6,44.58 69.6,44.2 68.96,43.56 68.96,42.42 68.83,42.29 64.52,42.29 64.39,42.42 64.39,43.56 63.75,44.2 63.75,44.58 64.01,44.83 69.34,44.83
GND on TOP (solid shape): 88.52,288.54 88.52,284.73 88.01,284.23 88.01,274.19 87.5,273.69 86.36,273.69 85.72,274.32 85.72,276.86 86.36,277.5 86.36,284.1 85.22,285.24 82.68,285.24 82.17,285.75 82.17,287.91 82.8,288.54 86.87,288.54 87.19,288.86 88.2,288.86
GND on TOP (solid shape): 75.95,44.58 75.95,44.2 75.31,43.56 74.02,43.56 73.89,43.43 73.89,42.39 73.79,42.29 71.75,42.29 71.67,42.38 71.67,43.4 71.5,43.56 70.74,43.56 70.1,44.2 70.1,44.58 70.36,44.83 75.69,44.83
GND on TOP (solid shape): 208.91,200.91 207.14,200.91 207.01,200.79 207.01,197.87 207.14,197.74 208.91,197.74 208.91,197.36 207.14,197.36 207.01,197.23 207.01,194.18 207.14,194.06 209.04,194.06 209.04,193.67 207.14,193.67 207.01,193.55 207.01,190.63 207.26,190.37 209.04,190.37 209.04,189.99 207.14,189.99 206.63,189.48 206.12,189.48 205.99,189.61 205.99,201.04 206.25,201.29 208.91,201.29
GND on TOP (solid shape): 158.62,211.84 158.62,203.58 158.5,203.45 151.82,203.45 151.69,203.58 151.69,206.57 151.69,209.29 151.84,209.29 151.84,206.57 152.96,206.57 152.96,208.09 154.32,208.09 154.32,208 155.89,208 157.61,208 157.61,209.32 155.89,209.32 154.32,209.32 154.32,209.23 152.96,209.23 152.96,209.29 151.69,209.29 151.69,210.49 153.16,211.96 158.5,211.96
