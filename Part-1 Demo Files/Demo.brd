# Allegro board Demo.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
C673  0.01uf  [CAP_0402]  -90.96 160.66 0 top
C674  0.1uf  [CAP_0603]  -91.14 142.15 0 top
C678  10uf  [CAPT_3528]  -55.19 6.08 0 top
C679  10uf  [CAPT_3528]  -61.54 302.51 0 top
C680  47uf  [CAPT_7343]  -84.03 51.19 0 top
C681  1uf  [CAP_0805]  -59.61 225.93 0 top
C682  1uf  [CAP_0805]  -59.61 221.82 0 top
C683  1uf  [CAP_0805]  -59.61 217.71 0 top
C684  0.1uf  [CAP_0603]  -59.29 269.63 0 top
C685  0.1uf  [CAP_0603]  -59.29 265.97 0 top
C686  10uf  [CAPT_3528]  -93.39 134.51 0 top
C687  10uf  [CAPT_3528]  -93.39 130.19 0 top
C688  10uf  [CAPT_3528]  -61.54 298.2 0 top
C689  10uf  [CAPT_3528]  -61.54 293.88 0 top
C690  10uf  [CAPT_3528]  -93.39 125.87 0 top
C691  0.1uf  [CAP_0603]  -59.29 262.31 0 top
C692  0.1uf  [CAP_0603]  -59.29 258.66 0 top
C693  10uf  [CAPT_3528]  -93.39 121.55 0 top
C694  0.1uf  [CAP_0603]  -59.29 255 0 top
C695  10uf  [CAPT_3528]  -93.39 117.24 0 top
C696  47uf  [CAPT_3528]  -93.39 112.92 0 top
C697  47uf  [CAPT_3528]  -93.39 108.6 0 top
C698  220uf  [CAPT_7343]  -95.42 70.25 0 top
C699  220uf  [CAPT_7343]  -95.42 64.4 0 top
C700  220uf  [CAPT_7343]  -95.42 58.56 0 top
C701  220uf  [CAPT_7343]  -95.42 52.72 0 top
C702  0.1uf  [CAP_0603]  -52.94 145.64 0 top
C703  0.1uf  [CAP_0603]  -52.94 141.99 0 top
C706  0.1uf  [CAP_0603]  -52.94 138.33 0 top
C711  0.001uf  [CAP_0402]  -90.96 48.66 0 top
C712  0.001uf  [CAP_0402]  -90.96 46.37 0 top
C713  0.001uf  [CAP_0402]  -90.96 44.08 0 top
C714  100uf  [CAPT_C]  -106.18 114.72 0 top
C715  0.1uf  [CAP_0603]  -52.94 134.68 0 top
C716  100uf  [CAPT_7343]  -106.18 219.2 0 top
C717  100uf  [CAPT_7343]  -106.18 119.29 0 top
C718  0.1uf  [CAP_0603]  -52.94 131.02 0 top
C719  0.1uf  [CAP_0603]  -52.94 127.37 0 top
C720  0.1uf  [CAP_0603]  -52.94 123.71 0 top
C721  0.1uf  [CAP_0603]  -52.94 120.05 0 top
C722  0.1uf  [CAP_0603]  -52.94 116.4 0 top
C725  0.01uf  [CAP_0402]  -102.35 160.66 0 top
C726  0.1uf  [CAP_0603]  -52.94 112.74 0 top
C727  47uf  [CAPT_3528]  -93.39 104.28 0 top
C728  0.01uf  [CAP_0603]  -79.75 131.02 0 top
C729  47uf  [CAPT_3528]  -93.39 99.96 0 top
C730  0.01uf  [CAP_0603]  -79.75 127.37 0 top
C731  47uf  [CAPT_3528]  -93.39 95.65 0 top
C732  0.01uf  [CAP_0603]  -79.75 123.71 0 top
C733  0.1uf  [CAP_0603]  -52.94 109.09 0 top
C734  47uf  [CAPT_3528]  -93.39 91.33 0 top
C735  0.1uf  [CAP_0603]  -52.94 105.43 0 top
C736  47uf  [CAPT_3528]  -93.39 87.01 0 top
C745  0.1uf  [CAP_0603]  -91.14 168.2 0 top
C746  0.1uf  [CAP_0603]  -52.94 101.77 0 top
C747  0.1uf  [CAP_0603]  -52.94 98.12 0 top
C748  0.1uf  [CAP_0603]  -52.94 94.46 0 top
C749  0.1uf  [CAP_0603]  -52.94 90.81 0 top
C750  0.1uf  [CAP_0603]  -52.94 87.15 0 top
C751  0.1uf  [CAP_0603]  -52.94 83.5 0 top
C752  0.01uf  [CAP_0402]  -90.96 158.37 0 top
C753  0.01uf  [CAP_0402]  -90.96 156.09 0 top
C754  470pf  [CAP_0402]  -90.96 6.75 0 top
C755  0.001uf  [CAP_0402]  -102.35 234.51 0 top
C756  0.1uf  [CAP_0402]  -90.96 289.81 0 top
C757  2.2uf  [CAPT_0603]  -102.53 293.7 0 top
C758  470pf  [CAP_0402]  -90.96 4.46 0 top
C759  0.001uf  [CAP_0402]  -102.35 236.8 0 top
C760  0.1uf  [CAP_0402]  -90.96 287.53 0 top
C761  2.2uf  [CAPT_0603]  -102.53 290.05 0 top
C762  470pf  [CAP_0402]  -90.96 2.17 0 top
C763  0.001uf  [CAP_0402]  -102.35 239.09 0 top
C764  0.1uf  [CAP_0402]  -90.96 285.24 0 top
C765  2.2uf  [CAPT_0603]  -102.53 286.39 0 top
C766  470pf  [CAP_0402]  -102.35 303.53 0 top
C767  0.001uf  [CAP_0402]  -102.35 241.37 0 top
C768  0.1uf  [CAP_0402]  -90.96 282.96 0 top
C769  2.2uf  [CAPT_0603]  -102.53 282.73 0 top
C770  470pf  [CAP_0402]  -102.35 301.24 0 top
C771  0.001uf  [CAP_0402]  -102.35 243.66 0 top
C772  0.1uf  [CAP_0402]  -90.96 280.67 0 top
C773  2.2uf  [CAPT_0603]  -102.53 279.08 0 top
C774  0.001uf  [CAP_0603]  -102.53 271.77 0 top
C775  470pf  [CAP_0402]  -102.35 298.96 0 top
C776  2.2uf  [CAP_0805]  -70.02 187.54 0 top
C777  1.0uf  [CAP_0805]  -80.07 73.69 0 top
C778  470pf  [CAP_0402]  -102.35 296.67 0 top
C779  0.001uf  [CAP_0402]  -102.35 245.94 0 top
C780  0.1uf  [CAP_0402]  -90.96 278.38 0 top
C781  2.2uf  [CAPT_0603]  -102.53 275.42 0 top
C782  100uf  [CAPT_7343]  -95.42 40.02 0 top
C783  100uf  [CAPT_7343]  -95.42 34.18 0 top
C784  100uf  [CAPT_7343]  -95.42 28.34 0 top
C785  100uf  [CAPT_7343]  -95.42 22.49 0 top
C786  220uf  [CAPT_7343]  -95.42 81.93 0 top
C787  220uf  [CAPT_7343]  -95.42 76.09 0 top
C788  100uf  [CAPT_7343]  -95.42 16.65 0 top
C789  100uf  [CAPT_7343]  -95.42 10.81 0 top
C790  1.0uf  [CAP_0805]  -80.07 94.24 0 top
CN1  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 241.05 0 top
CN2  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 262.49 0 top
CN3  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 266.78 0 top
CN4  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 271.07 0 top
CN5  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 275.36 0 top
CN6  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 279.65 0 top
CN7  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 236.76 0 top
CN8  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 283.94 0 top
CN9  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 232.47 0 top
CN10  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 245.33 0 top
CN11  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 249.62 0 top
CN12  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 253.91 0 top
CN13  0.1uf  [8_PINS_SURFACE_MOUNT]  -155.7 258.2 0 top
CON3  VAL  [CFCONN50P]  -25.15 297.56 0 top
HS1  XXX  [HEATSINK-7106D]  162.5 257.94 0 bottom
HS2  XXX  [HEATSINK-7106D]  249.87 36.45 0 bottom
ISO1  XXX  [DIP8]  22.23 202.56 0 top
J1  XXX  [CON120_HM-ZD]  175.26 303.27 180 top
J2  XXX  [VERT_SM_SMA]  237.49 295.91 0 top
J3  XXX  [VERT_SM_SMA]  250.19 295.91 0 top
J4  XXX  [VERT_SM_SMA]  262.89 295.91 0 top
J5  XXX  [VERT_SM_SMA]  275.59 295.91 0 top
J6  XXX  [VERT_SM_SMA]  288.29 295.91 0 top
J11  XXX  [HSSDC2]  326.06 281.3 0 top
J15  XXX  [HSSDC2]  326.06 264.16 0 top
J16  XXX  [VERT_SM_SMA]  219.71 257.81 0 top
J17  XXX  [VERT_SM_SMA]  250.19 255.27 0 top
J18  XXX  [VERT_SM_SMA]  262.89 255.27 0 top
J19  XXX  [VERT_SM_SMA]  275.59 255.27 0 top
J20  XXX  [VERT_SM_SMA]  288.29 255.27 0 top
J23  XXX  [HSSDC2]  326.06 247.01 0 top
J24  XXX  [VERT_SM_SMA]  219.71 245.11 0 top
J25  XXX  [VERT_SM_SMA]  250.19 242.57 0 top
J26  XXX  [VERT_SM_SMA]  262.89 242.57 0 top
J27  XXX  [VERT_SM_SMA]  275.59 242.57 0 top
J28  XXX  [VERT_SM_SMA]  288.29 242.57 0 top
J29  XXX  [VERT_SM_SMA]  154.94 236.22 270 top
J30  XXX  [VERT_SM_SMA]  167.64 236.22 0 top
J31  XXX  [MOLEX-10X2]  28.83 249.43 90 top
J32  XXX  [HSSDC2]  326.06 229.87 0 top
J34  XXX  [MICTOR]  279.4 226.06 0 top
J36  VAL  [HDR2X4_100MIL]  230.25 276.23 270 top
J37  XXX  [VERT_SM_SMA]  152.4 191.77 270 top
J38  XXX  [SFP]  298.98 204.26 90 top
J42  XXX  [TEK_PROBE]  210.19 196.85 90 top
J43  XXX  [VERT_SM_SMA]  152.4 179.07 0 top
J45  XXX  [SFP]  298.98 183.94 90 top
J46  XXX  [VERT_SM_SMA]  110.49 176.53 90 top
J47  XXX  [VERT_SM_SMA]  124.46 176.53 90 top
J48  XXX  [TH-CONN-2-P1]  19.69 186.69 270 top
J49  XXX  [VERT_SM_SMA]  165.1 182.88 270 top
J52  XXX  [VERT_SM_SMA]  252.73 173.35 90 top
J53  XXX  [TSM-110-01-G-DV]  266.7 170.18 0 top
J54  XXX  [SFP]  298.98 163.62 90 top
J55  XXX  [TH-CONN-2-P1]  132.72 165.1 0 top
J56  XXX  [TH-CONN-2-P1]  150.5 165.1 180 top
J57  XXX  [SMT_A_PROBE]  225.42 161.93 270 top
J58  XXX  [SMT_A_PROBE]  236.85 161.93 270 top
J59  XXX  [TEK_PROBE]  210.19 161.92 90 top
J60  XXX  [VERT_SM_SMA]  252.73 160.66 90 top
J61  XXX  [VERT_SM_SMA]  127.63 158.11 90 top
J62  XXX  [VERT_SM_SMA]  142.24 158.11 90 top
J63  XXX  [TSM-105-01-L-DV]  266.7 147.32 0 top
J64  XXX  [SFP]  298.98 143.3 90 top
J68  XXX  [TSM-110-01-G-DV]  170.81 146.05 180 top
J69  XXX  [VERT_SM_SMA]  210.82 138.43 0 top
J72  XXX  [EDGE_LAUNCHED_SMA]  329.39 128.31 0 top
J75  XXX  [MICTOR]  102.23 146.05 180 top
J76  XXX  [VERT_SM_SMA]  207.64 117.47 0 top
J77  XXX  [EDGE_LAUNCHED_SMA]  329.39 113.07 0 top
J78  XXX  [HDR2X10_100MIL]  39.37 106.68 270 top
J79  XXX  [HDR2X7_100MIL]  68.58 106.68 270 top
J80  XXX  [VERT_SM_SMA]  196.22 102.87 270 top
J81  XXX  [EDGE_LAUNCHED_SMA]  329.39 97.83 0 top
J83  XXX  [VERT_SM_SMA]  279.4 93.98 0 top
J84  XXX  [VERT_SM_SMA]  299.72 93.98 0 top
J85  XXX  [TSM-105-01-L-DV]  96.52 91.44 270 top
J86  XXX  [EDGE_LAUNCHED_SMA]  329.39 82.59 0 top
J87  XXX  [10_PIN_CONNECTOR]  96.52 80.64 270 top
J88  XXX  [VERT_SM_SMA]  279.4 78.74 0 top
J89  XXX  [VERT_SM_SMA]  299.72 78.74 0 top
J90  XXX  [TH-CONN-2-P1]  132.08 75.56 90 top
J91  XXX  [VERT_SM_SMA]  177.8 74.93 270 top
J92  XXX  [HDR2X20_100MIL]  52.07 73.66 270 top
J93  XXX  [EDGE_LAUNCHED_SMA]  329.39 67.32 0 top
J94  XXX  [VERT_SM_SMA]  279.4 63.5 0 top
J95  XXX  [VERT_SM_SMA]  299.72 63.5 0 top
J97  XXX  [VERT_SM_SMA]  196.85 54.61 90 top
J98  XXX  [EDGE_LAUNCHED_SMA]  329.39 52.08 0 top
J99  XXX  [VERT_SM_SMA]  279.4 48.26 0 top
J100  XXX  [VERT_SM_SMA]  299.72 48.26 0 top
J101  XXX  [EDGE_LAUNCHED_SMA]  329.39 36.73 0 top
J102  XXX  [VERT_SM_SMA]  279.4 33.02 0 top
J103  XXX  [VERT_SM_SMA]  299.72 33.02 0 top
J104  XXX  [VERT_SM_SMA]  177.8 31.75 90 top
J105  XXX  [EDGE_LAUNCHED_SMA]  329.39 21.49 0 top
J106  XXX  [VERT_SM_SMA]  279.4 17.78 0 top
J107  XXX  [VERT_SM_SMA]  299.72 17.78 0 top
J108  XXX  [CON120_HM-ZD]  167.46 1.91 0 top
J109  XXX  [CON120_HM-ZD]  204.47 1.91 0 top
J111  XXX  [TH-CONN-2-P1]  28.32 257.68 180 top
J112  XXX  [TH-CONN-2-P1]  154.43 267.08 0 top
J113  XXX  [TH-CONN-2-P1]  156.21 204.72 270 top
J114  XXX  [TH-CONN-2-P1]  136.14 278.38 0 top
J121  XXX  [VERT_SM_SMA]  313.69 295.91 0 top
J122  XXX  [VERT_SM_SMA]  300.99 295.91 0 top
J123  VAL  [HDR2X2_100MIL]  230.25 285.75 270 top
J124  XXX  [DB9DOUBLE]  16.51 49.53 90 top
NOREF  -  []  165.73 167.64 0 top
NOREF#2  -  [unnamed#2]  219.71 226.06 0 top
NOREF#3  -  []  5.84 280.47 0 top
NOREF#4  -  []  6.35 6.35 0 top
NOREF#5  -  []  6.35 6.35 0 top
NOREF#6  -  [unnamed#2]  326.39 292.1 0 top
NOREF#7  -  [unnamed#2]  162.56 161.29 0 top
NOREF#8  -  [unnamed#2]  165.73 173.99 0 top
NOREF#9  -  []  165.73 167.64 0 top
NOREF#10  -  []  -39.38 -132.66 0 top
NOREF#11  -  [unnamed#2]  63.5 116.84 0 top
NOREF#12  -  [unnamed#2]  222.25 127 0 top
NOREF#13  -  [unnamed#2]  245.11 6.22 0 top
NOREF#14  -  []  323.85 6.35 0 top
NOREF#15  -  []  -316.23 56.52 0 top
NOREF#16  -  []  330.2 0 0 top
NOREF#17  -  [unnamed#2]  313.69 13.97 0 top
NOREF#18  -  [unnamed#2]  25.4 7.62 0 top
NOREF#19  -  [unnamed#2]  229.23 301.62 0 top
NOREF#20  -  []  0.63 304.8 0 top
NOREF#21  -  [unnamed#2]  101.6 10.79 0 top
NOREF#22  -  [unnamed#2]  210.82 17.78 0 top
NOREF#23  -  [unnamed#2]  111.76 110.49 0 top
NOREF#24  -  []  323.85 6.35 0 top
NOREF#25  -  []  75.34 280.47 0 top
NOREF#26  -  []  6.35 298.45 0 top
NOREF#27  -  []  0 0 0 top
NOREF#28  -  [unnamed#2]  275.59 199.39 0 top
NOREF#29  -  [unnamed#2]  6.35 289.56 0 top
NOREF#30  -  [unnamed#2]  326.39 292.1 180 bottom
NOREF#31  -  [unnamed#2]  229.23 301.62 180 bottom
NOREF#32  -  [unnamed#2]  6.35 289.56 180 bottom
NOREF#33  -  [unnamed#2]  245.11 6.22 180 bottom
NOREF#34  -  [unnamed#2]  63.5 116.84 180 bottom
NOREF#35  -  [unnamed#2]  210.82 17.78 180 bottom
NOREF#36  -  [unnamed#2]  25.4 7.62 180 bottom
NOREF#37  -  [unnamed#2]  313.69 13.97 180 bottom
NOREF#38  -  [unnamed#2]  101.6 10.79 180 bottom
NOREF#39  -  [unnamed#2]  165.73 173.99 180 bottom
PMCJN1  XXX  [SMT]  22.09 164.46 0 bottom
PMCJN2  XXX  [SMT]  22.09 150.46 0 bottom
R2  0.056  [THRU_HOLE]  -141.15 49.7 0 top
R3  100  [RES_0402]  -137.2 32.51 0 top
R4  104  [RES_0603]  -144.92 150.21 0 top
R5  20  [RES_0603]  -144.92 146.55 0 top
R6  100  [RES_0402]  -137.2 16.51 0 top
R7  56  [RES_0603]  -111.67 96.71 0 top
R11  56  [RES_0603]  -111.67 136.92 0 top
R15  104  [RES_0402]  -139.05 274.73 0 top
R16  78.7  [RES_0402]  -139.05 256.44 0 top
R17  6.65K  [RES_0402]  -139.05 129.85 0 top
R18  100  [RES_0402]  -137.2 55.37 0 top
R19  4.42K  [RES_0402]  -139.05 70.45 0 top
R21  0  [RES_0402]  -139.05 43.58 0 top
R23  56  [RES_0603]  -111.67 107.68 0 top
R27  162  [RES_0402]  -144.74 263.32 0 top
R28  1.0K  [RES_0402]  -139.05 27.12 0 top
R30  56  [RES_0603]  -111.67 104.02 0 top
R31  1.0K  [RES_0402]  -139.05 24.84 0 top
R32  1.0K  [RES_0402]  -139.05 22.55 0 top
R33  100  [RES_0402]  -137.2 30.22 0 top
R34  2.7K  [RES_0402]  -144.74 171.91 0 top
R35  162  [RES_0402]  -144.74 261.03 0 top
R37  10.0K  [RES_0603]  -137.38 160.27 0 top
R39  1.0K  [RES_0603]  -137.38 284.57 0 top
R40  162  [RES_0402]  -144.74 258.74 0 top
R41  1.0K  [RES_0603]  -137.38 280.91 0 top
R42  10.0K  [RES_0603]  -137.38 156.61 0 top
R43  100  [RES_0402]  -137.2 18.79 0 top
R44  1.0K  [RES_0603]  -137.38 277.25 0 top
R46  162  [RES_0402]  -144.74 256.46 0 top
R47  162  [RES_0402]  -144.74 254.17 0 top
R48  162  [RES_0402]  -144.74 251.89 0 top
R51  10.0K  [RES_0603]  -137.38 152.96 0 top
R52  22  [RES_0402]  -137.2 129.87 0 top
R53  1.0K  [RES_0603]  -137.38 273.6 0 top
R55  10.0K  [RES_0603]  -137.38 149.3 0 top
R56  1.0K  [RES_0603]  -137.38 269.94 0 top
R57  1.0K  [RES_0603]  -137.38 266.29 0 top
R60  100  [RES_0402]  -137.2 14.22 0 top
R61  100  [RES_0402]  -137.2 11.94 0 top
R62  4.7  [RES_0603]  -139.23 60.16 0 top
R65  2.5K  [RES_0603]  -144.92 69.78 0 top
R66  2.5K  [RES_0603]  -144.92 73.44 0 top
R67  2.5K  [RES_0603]  -144.92 77.09 0 top
R68  1.0K  [RES_0603]  -137.38 262.63 0 top
R70  56  [RES_0603]  -111.67 93.05 0 top
R71  4.7  [RES_0603]  -139.23 56.51 0 top
R73  56  [RES_0603]  -111.67 85.74 0 top
R74  1.0K  [RES_0402]  -139.05 20.27 0 top
R75  1.0K  [RES_0402]  -139.05 17.98 0 top
R76  10.0K  [RES_0603]  -144.92 142.9 0 top
R77  10.0K  [RES_0603]  -144.92 139.24 0 top
R80  2.5K  [RES_0603]  -144.92 80.75 0 top
R81  2.5K  [RES_0603]  -144.92 84.4 0 top
R82  2.5K  [RES_0603]  -144.92 88.06 0 top
R83  2.5K  [RES_0603]  -144.92 91.71 0 top
R84  2.5K  [RES_0603]  -144.92 95.37 0 top
R85  2.5K  [RES_0603]  -144.92 99.03 0 top
R86  100  [RES_0402]  -139.05 183.31 0 top
R87  104  [RES_0402]  -139.05 265.58 0 top
R88  78.7  [RES_0402]  -139.05 247.3 0 top
R89  78.7  [RES_0402]  -139.05 245.01 0 top
R90  104  [RES_0402]  -139.05 263.3 0 top
R91  104  [RES_0402]  -139.05 261.01 0 top
R92  78.7  [RES_0402]  -139.05 242.72 0 top
R93  78.7  [RES_0402]  -139.05 240.44 0 top
R94  104  [RES_0402]  -139.05 258.73 0 top
R98  10.0K  [RES_0603]  6.35 144.14 0 top
R99  2.5K  [RES_0603]  -144.92 102.68 0 top
R100  2.5K  [RES_0603]  -144.92 66.12 0 top
R101  2.0K  [RES_0603]  -144.92 106.34 0 top
R102  11.0K  [RES_0603]  -144.92 128.27 0 top
R103  24.9  [RES_0603]  -111.67 184.45 0 top
R104  24.9  [RES_0603]  -111.67 180.79 0 top
R105  60.0K  [RES_0603]  -111.67 162.51 0 top
R106  60.0K  [RES_0603]  -111.67 169.83 0 top
R107  60.0K  [RES_0603]  -111.67 166.17 0 top
R108  60.0K  [RES_0603]  -111.67 151.55 0 top
R109  60.0K  [RES_0603]  -111.67 158.86 0 top
R110  60.0K  [RES_0603]  -111.67 155.2 0 top
R111  60.0K  [RES_0603]  -111.67 129.61 0 top
R112  60.0K  [RES_0603]  -111.67 147.89 0 top
R113  60.0K  [RES_0603]  -111.67 144.24 0 top
R114  60.0K  [RES_0603]  -111.67 140.58 0 top
R115  499  [RES_0603]  -111.67 78.43 0 top
R116  24.9  [RES_0603]  -111.67 173.48 0 top
R117  22K  [RES_0603]  -111.67 74.77 0 top
R118  24.9  [RES_0603]  -111.67 177.14 0 top
R119  1.0K  [RES_0603]  -111.67 71.12 0 top
R120  1.0K  [RES_0603]  -111.67 67.46 0 top
R121  11.0K  [RES_0603]  -144.92 131.93 0 top
R122  30K  [RES_0603]  -137.38 258.98 0 top
R123  10.0K  [RES_0603]  -137.38 255.32 0 top
R124  200  [RES_0603]  -137.38 8.97 0 top
R125  11.0K  [RES_0603]  -144.92 135.58 0 top
R126  NI  [RES_0402]  -137.2 139.02 0 top
R127  22  [RES_0402]  -137.2 132.16 0 top
R128  11.0K  [RES_0603]  -111.67 188.1 0 top
R129  23  [RES_0603]  -137.38 126.9 0 top
R130  1.0K  [RES_0603]  -111.67 63.81 0 top
R131  250  [RES_0603]  -137.38 123.25 0 top
R132  250  [RES_0603]  -137.38 119.59 0 top
R133  10.0K  [RES_0603]  -137.38 251.66 0 top
R134  47  [RES_0603]  -137.38 94 0 top
R135  100  [RES_0402]  -137.2 87.37 0 top
R136  56  [RES_0402]  -137.2 5.99 0 top
R137  100  [RES_0402]  -137.2 85.09 0 top
R138  100  [RES_0402]  -137.2 82.8 0 top
R139  49.9  [RES_0603]  -137.38 3.02 0 top
R140  1.0K  [RES_0603]  -111.67 19.94 0 top
R141  49.9  [RES_0603]  -139.23 302.85 0 top
R142  10.0K  [RES_0603]  -137.38 248.01 0 top
R143  10.0K  [RES_0603]  -137.38 244.35 0 top
R144  10.0K  [RES_0603]  -137.38 240.7 0 top
R145  10.0K  [RES_0603]  -137.38 237.04 0 top
R146  10.0K  [RES_0603]  -137.38 233.38 0 top
R147  10.0K  [RES_0603]  -137.38 145.64 0 top
R148  10.0K  [RES_0603]  -137.38 226.07 0 top
R149  NI  [RES_0402]  -139.05 299.87 0 top
R150  100  [RES_0402]  -137.2 80.52 0 top
R151  100  [RES_0402]  -137.2 78.23 0 top
R152  100  [RES_0402]  -137.2 75.94 0 top
R153  100  [RES_0402]  -137.2 73.66 0 top
R154  100  [RES_0402]  -137.2 71.37 0 top
R155  100  [RES_0402]  -137.2 69.09 0 top
R156  100  [RES_0402]  -137.2 66.8 0 top
R157  100  [RES_0402]  -137.2 64.51 0 top
R158  10.0K  [RES_0603]  -137.38 222.42 0 top
R159  1.0K  [RES_0603]  -111.67 56.5 0 top
R160  1.0K  [RES_0603]  -111.67 52.84 0 top
R161  4.7K  [RES_0603]  -139.23 237.47 0 top
R162  4.7K  [RES_0603]  -139.23 233.81 0 top
R163  1.0K  [RES_0603]  -139.23 143.79 0 top
R164  1.0K  [RES_0603]  -139.23 140.13 0 top
R165  100  [RES_0402]  -137.2 62.23 0 top
R167  100  [RES_0402]  -137.2 59.94 0 top
R168  100  [RES_0402]  -137.2 57.66 0 top
R169  1.0K  [RES_0603]  -139.23 136.47 0 top
R170  1.0K  [RES_0603]  -139.23 132.82 0 top
R171  NI  [RES_0402]  -139.05 297.59 0 top
R172  1.0K  [RES_0603]  -111.67 49.18 0 top
R173  4.7K  [RES_0603]  -139.23 230.16 0 top
R174  4.7K  [RES_0603]  -139.23 226.5 0 top
R175  20.0K  [RES_0603]  -139.23 126.88 0 top
R176  49.9  [RES_0402]  -139.05 123.91 0 top
R177  49.9  [RES_0402]  -139.05 121.62 0 top
R178  0  [RES_0603]  -139.23 111.34 0 top
R179  0  [RES_0603]  -139.23 107.68 0 top
R180  NI  [RES_0402]  -139.05 295.3 0 top
R181  NI  [RES_0402]  -139.05 293.02 0 top
R182  NI  [RES_0402]  -139.05 290.73 0 top
R183  NI  [RES_0402]  -139.05 288.44 0 top
R184  NI  [RES_0402]  -139.05 286.16 0 top
R185  200  [RES_0805]  -139.55 81.86 0 top
R186  NI  [RES_0402]  -139.05 283.87 0 top
R187  226  [RES_0805]  -139.55 77.75 0 top
R189  10k  [RES_0805]  -139.55 73.64 0 top
R190  4.7  [RES_0603]  -139.23 67.47 0 top
R191  78.7  [RES_0402]  -139.05 254.15 0 top
R192  104  [RES_0402]  -139.05 272.44 0 top
R193  104  [RES_0402]  -139.05 270.16 0 top
R194  78.7  [RES_0402]  -139.05 251.87 0 top
R195  104  [RES_0402]  -139.05 267.87 0 top
R196  78.7  [RES_0402]  -139.05 249.58 0 top
R202  4.7  [RES_0603]  -139.23 63.82 0 top
R203  NI  [RES_0402]  -139.05 281.59 0 top
R204  200  [RES_0603]  -137.38 141.99 0 top
R205  4.7K  [RES_0603]  -139.23 222.84 0 top
R206  4.7K  [RES_0603]  -139.23 219.19 0 top
R207  1.0K  [RES_0603]  -111.67 45.53 0 top
R208  NI  [RES_0402]  -139.05 279.3 0 top
R209  4.7K  [RES_0603]  -139.23 215.53 0 top
R210  4.7K  [RES_0603]  -139.23 211.88 0 top
R211  4.7K  [RES_0603]  -139.23 208.22 0 top
R212  NI  [RES_0402]  -139.05 277.01 0 top
R214  100  [RES_0402]  -137.2 53.08 0 top
R215  10k  [RES_0402]  -139.05 39.01 0 top
R216  10.0K  [RES_0603]  -137.38 218.76 0 top
R217  4.7K  [RES_0603]  -139.23 204.56 0 top
R218  4.7K  [RES_0603]  -139.23 200.91 0 top
R219  4.7K  [RES_0603]  -139.23 197.25 0 top
R220  4.7K  [RES_0603]  -139.23 193.6 0 top
R221  4.7K  [RES_0603]  -139.23 189.94 0 top
R222  93  [RES_0603]  -139.23 36.04 0 top
R223  158  [RES_0603]  -139.23 32.38 0 top
R224  4.7K  [RES_0603]  -139.23 186.29 0 top
R225  1.0K  [RES_0402]  -139.05 29.41 0 top
R226  4.7K  [RES_0603]  -147.41 295.53 0 top
R227  4.7K  [RES_0603]  -139.23 180.34 0 top
R228  4.7K  [RES_0603]  -139.23 176.69 0 top
R229  4.7K  [RES_0603]  -139.23 173.03 0 top
R230  4.7K  [RES_0603]  -139.23 169.38 0 top
R231  10.0K  [RES_0603]  -137.38 215.11 0 top
R232  10.0K  [RES_0603]  -137.38 211.45 0 top
R233  10.0K  [RES_0603]  -137.38 207.79 0 top
R235  4.7K  [RES_0603]  -139.23 165.72 0 top
R236  56  [RES_0603]  -111.67 122.3 0 top
R237  4.7K  [RES_0603]  -139.23 162.06 0 top
R238  56  [RES_0603]  -111.67 118.64 0 top
R239  4.7K  [RES_0603]  -139.23 158.41 0 top
R241  4.7K  [RES_0603]  -139.23 154.75 0 top
R242  250  [RES_0603]  -139.23 15.01 0 top
R243  49.9  [RES_0402]  -139.05 12.04 0 top
R244  49.9  [RES_0402]  -139.05 9.75 0 top
R247  1.0K  [RES_0603]  -137.38 90.34 0 top
R248  787  [RES_0603]  -144.92 3.97 0 top
R249  15.0K  [RES_0603]  -139.23 6.78 0 top
R250  15.0K  [RES_0603]  -139.23 3.13 0 top
R251  15.0K  [RES_0603]  -144.92 302.85 0 top
R252  15.0K  [RES_0603]  -144.92 299.19 0 top
R253  15.0K  [RES_0603]  -144.92 295.53 0 top
R254  15.0K  [RES_0603]  -144.92 291.88 0 top
R255  15.0K  [RES_0603]  -144.92 288.22 0 top
R256  15.0K  [RES_0603]  -144.92 284.57 0 top
R257  15.0K  [RES_0603]  -144.92 280.91 0 top
R258  15.0K  [RES_0603]  -144.92 277.25 0 top
R259  0  [RES_0603]  -144.92 273.6 0 top
R260  1.0K  [RES_0603]  -111.67 41.87 0 top
R261  47  [RES_0603]  -144.92 269.94 0 top
R262  1.0K  [RES_0603]  -111.67 38.22 0 top
R263  1.0K  [RES_0603]  -111.67 34.56 0 top
R264  1.0K  [RES_0603]  -111.67 30.9 0 top
R265  1.0K  [RES_0603]  -111.67 27.25 0 top
R266  1.0K  [RES_0603]  -111.67 23.59 0 top
R267  1.0K  [RES_0603]  -137.38 229.73 0 top
R268  1.0K  [RES_0603]  -111.67 16.28 0 top
R269  1.0K  [RES_0603]  -111.67 12.63 0 top
R270  100  [RES_0402]  -137.2 50.8 0 top
R271  100  [RES_0402]  -137.2 48.51 0 top
R272  100  [RES_0402]  -137.2 46.23 0 top
R273  100  [RES_0402]  -137.2 43.94 0 top
R274  100  [RES_0402]  -137.2 41.65 0 top
R275  100  [RES_0402]  -137.2 39.37 0 top
R276  100  [RES_0402]  -137.2 37.08 0 top
R277  100  [RES_0402]  -137.2 34.8 0 top
R278  1.0K  [RES_0603]  -111.67 8.97 0 top
R279  10.0K  [RES_0603]  -137.38 204.14 0 top
R280  10.0K  [RES_0603]  -137.38 200.48 0 top
R281  10.0K  [RES_0603]  -137.38 196.83 0 top
R282  1.0K  [RES_0603]  -111.67 5.31 0 top
R283  1.0K  [RES_0603]  -111.67 1.66 0 top
R284  1.0K  [RES_0603]  -137.38 302.85 0 top
R285  1.0K  [RES_0603]  -137.38 299.19 0 top
R286  1.0K  [RES_0603]  -137.38 295.53 0 top
R289  10.0K  [RES_0603]  -137.38 193.17 0 top
R290  10.0K  [RES_0603]  -137.38 189.51 0 top
R291  10.0K  [RES_0603]  -137.38 185.86 0 top
R292  10.0K  [RES_0603]  -137.38 182.2 0 top
R293  10.0K  [RES_0603]  -137.38 178.55 0 top
R294  10.0K  [RES_0603]  -137.38 174.89 0 top
R296  1.0K  [RES_0603]  -137.38 291.88 0 top
R297  78.7  [RES_0603]  -144.92 248.92 0 top
R298  47  [RES_0603]  -144.92 266.29 0 top
R299  1.0K  [RES_0603]  -137.38 288.22 0 top
R300  47  [RES_0603]  -144.92 245.26 0 top
R301  47  [RES_0603]  -144.92 241.6 0 top
R303  1.0K  [RES_0603]  -144.92 237.95 0 top
R304  10.0K  [RES_0603]  -144.92 230.64 0 top
R305  1.0K  [RES_0603]  -144.92 234.29 0 top
R306  5.6K  [RES_0603]  -144.92 219.67 0 top
R307  5.6K  [RES_0603]  -144.92 216.01 0 top
R318  10.0K  [RES_0603]  -144.92 226.98 0 top
R319  10.0K  [RES_0603]  -144.92 223.32 0 top
R322  100  [RES_0402]  -144.74 209.39 0 top
R323  100  [RES_0402]  -144.74 207.1 0 top
R324  0  [RES_0603]  -139.23 104.03 0 top
R326  0  [RES_0603]  -139.23 100.37 0 top
R327  0  [RES_0603]  -139.23 114.99 0 top
R329  NI  [RES_0603]  -144.92 204.13 0 top
R330  NI  [RES_0603]  -144.92 200.47 0 top
R331  NI  [RES_0603]  -144.92 196.82 0 top
R332  NI  [RES_0603]  -144.92 193.16 0 top
R333  NI  [RES_0603]  -144.92 189.51 0 top
R334  0  [RES_0603]  -139.23 96.71 0 top
R335  0  [RES_0603]  -139.23 93.06 0 top
R336  0  [RES_0603]  -139.23 89.4 0 top
R337  0  [RES_0603]  -139.23 85.75 0 top
R338  NI  [RES_0603]  -144.92 185.85 0 top
R339  NI  [RES_0603]  -144.92 182.19 0 top
R340  NI  [RES_0603]  -144.92 178.54 0 top
R341  NI  [RES_0603]  -144.92 174.88 0 top
R342  100  [RES_0402]  -137.2 27.94 0 top
R343  100  [RES_0402]  -137.2 25.65 0 top
R344  0  [RES_0402]  -139.05 41.29 0 top
R345  NI  [RES_0402]  -137.2 136.73 0 top
R346  100  [RES_0402]  -137.2 23.37 0 top
R347  100  [RES_0402]  -137.2 21.08 0 top
R348  0  [RES_0603]  -144.92 168.94 0 top
R349  0  [RES_0603]  -144.92 165.28 0 top
R350  NI  [RES_0603]  -144.92 161.63 0 top
R351  NI  [RES_0603]  -144.92 157.97 0 top
R352  750K  [RES_0805]  -145.24 154.09 0 top
R353  5.6K  [RES_0603]  -144.92 212.36 0 top
R354  3.0K  [RES_0603]  -147.41 299.19 0 top
R355  NI  [RES_0402]  -137.2 134.45 0 top
R357  6.2K  [RES_0603]  -147.41 302.85 0 top
R358  10.0K  [RES_0603]  -137.38 171.24 0 top
R359  10.0K  [RES_0603]  -137.38 167.58 0 top
R360  10.0K  [RES_0603]  -137.38 163.92 0 top
R361  0  [RES_0603]  -139.23 118.65 0 top
RJ1  XXX  [RJ426]  -119.16 202.11 0 top
RN5  56  [16_PIN_SMD]  -112.58 192.43 0 top
RN14  1.0K  [RPACK8]  -112.58 282.18 0 top
RN15  10K  [RN_SMT]  -112.58 302.17 0 top
RN16  10K  [RN_SMT]  -103.44 6.3 0 top
RN17  10K  [RN_SMT]  -103.44 11.3 0 top
RN18  10K  [RN_SMT]  -103.44 16.3 0 top
RN19  10.0K  [RN_SMT]  -103.44 21.3 0 top
RN20  10.0K  [RN_SMT]  -103.44 26.3 0 top
RN21  220  [RN_SMT]  -103.44 31.3 0 top
RN22  220  [RN_SMT]  -103.44 36.29 0 top
RN23  56  [16_PIN_SMD]  -103.44 61.29 0 top
RN24  56  [16_PIN_SMD]  -103.44 66.29 0 top
RN25  56  [16_PIN_SMD]  -103.44 71.28 0 top
RN26  56  [16_PIN_SMD]  -103.44 76.28 0 top
RN27  56  [16_PIN_SMD]  -103.44 81.28 0 top
RN28  56  [16_PIN_SMD]  -103.44 86.28 0 top
RN29  56  [16_PIN_SMD]  -103.44 91.28 0 top
RN30  56  [16_PIN_SMD]  -103.44 96.28 0 top
RN31  56  [16_PIN_SMD]  -103.44 101.28 0 top
RN32  56  [16_PIN_SMD]  -103.44 106.27 0 top
RN33  220  [RN_SMT]  -103.44 41.29 0 top
RN34  220  [RN_SMT]  -103.44 46.29 0 top
RN35  220  [RN_SMT]  -103.44 51.29 0 top
RN36  220  [RN_SMT]  -103.44 56.29 0 top
RN37  1.0K  [RPACK8]  -112.58 287.18 0 top
RN38  1.0K  [RPACK8]  -112.58 292.18 0 top
RN39  1.0K  [RPACK8]  -112.58 297.18 0 top
U1  XXX  [TO263_5]  162.5 258.57 270 bottom
U2  XXX  [TO263]  249.87 36.45 0 bottom
U4  XXX  [TSSOP_8]  165.73 217.17 270 top
U5  XXX  [QSOP16]  266.7 209.55 270 top
U6  XXX  [TSSOP20]  165.1 205.1 270 top
U7  XXX  [F1020]  233.81 208.66 90 top
U8  XXX  [BRICK7]  98.68 186.82 180 top
U9  VAL  [TSSOP8]  164.47 192.41 270 top
U10  XXX  [LQFP_32]  139.05 173.99 90 top
U11  XXX  [TQFP128P]  45.72 137.79 0 top
U12  XXX  [QSOP16]  114.93 133.35 180 top
U13  XXX  [SOIC8]  203.2 131.44 90 top
U14  XXX  [SOG_05]  284.86 123.95 0 bottom
U15  XXX  [F1020]  145.41 128.91 90 top
U17  XXX  [SOG_65]  293.12 123.44 270 bottom
U18  XXX  [TSSOP20]  181.61 98.42 90 top
U19  XXX  [SO40]  118.74 93.34 270 top
U20  XXX  [SO40]  132.72 93.34 90 top
U21  XXX  [SO40]  148.59 93.34 90 top
U22  XXX  [SO24]  32.38 89.53 270 top
U23  XXX  [SO24]  50.8 89.53 270 top
U24  XXX  [SO24]  68.58 89.53 270 top
U25  XXX  [TSSOP48]  145.41 76.2 90 top
U26  XXX  [TSSOP48]  163.19 76.2 90 top
U27  XXX  [XPAK1]  247.65 123.82 0 top
U28  XXX  [SOG_50]  25.4 60.96 180 top
U29  XXX  [PQFP100_720X956]  95.25 55.88 0 top
U30  XXX  [PQFP100_720X956]  123.19 55.88 0 top
U31  XXX  [TSOP48]  56.52 55.25 180 top
U32  XXX  [TSSOP20]  181.61 55.25 90 top
U33  XXX  [SOG_50]  25.4 46.99 180 top
U34  XXX  [TSSOP48]  69.85 32.38 90 top
U36  XXX  [SOIC20]  146.69 203.45 270 top
U37  XXX  [SOIC20]  137.41 268.86 0 top
U38  VAL  [SO8]  144.91 280.67 90 top
U39  XXX  [SO24]  68.58 104.77 90 bottom
U42  XXX  [TO263_5]  55.8 262.18 0 top
U43  VAL  [SOIC16F]  38.1 60.96 180 top
U44  VAL  [SOIC16F]  38.1 46.99 180 top
U45  XXX  [BRICK_8]  98.68 219.2 180 top
U46  XXX  [SOIC8]  196.88 61.93 0 top
U47  XXX  [SOIC8]  198.5 110.24 0 top
U52  XXX  [SO24]  50.8 104.77 90 bottom
U53  -  [SO8N]  157.48 274.32 270 top
U59  VAL  [SSOT6]  14.72 95.45 270 top
U60  VAL  [SOT23-5]  172.09 199.64 90 bottom
XU2  -  [DIMM240]  191.9 208.66 90 top
Y1  XXX  [4P_OSC]  210.19 129.54 270 top
Y2  XXX  [4P_OSC]  179.7 86.36 90 top
Y3  XXX  [4P_OSC]  179.7 43.18 90 top
Y4  XXX  [PACKAGE_D]  34.29 120.02 180 top

## Library data of the parts
C1-C8 C10 C11 C17 C18 C20-C25 C29-C32 C83 C101 C104 C105 C115 C518 C526 C532 C667 C668 C673 C725 C752 C753 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1C103K; part number: CAP_SMD_NPOL_0-0.01UF,5%,CAP_0402; signal model: DEFAULT_CAPACITOR_10000pF_2_1
C9 C14 C15 = CAP_SMD_NPOL_0: User Part Number: ECJ-3YF1A106Z; Tolerance: XXX; part number: CAP_SMD_NPOL_0-10UF,5%,CAP_1206; signal model: DEFAULT_CAPACITOR_1e+07pF_2_1
C12 C50-C53 C60 C72 C77 C80 C678 C679 C686-C690 C693 C695 = CAP_SMD_POL_0: User Part Number: ECS-T1AX106R; Tolerance: TOL; part number: CAP_SMD_POL_0-10UF,5%,10V,CAPT_3528; signal model: DEFAULT_CAPACITOR_1e+07pF_2_1
C13 C16 C44 C45 C54 C55 C84 C87 C89 C90 C92 C102 C110-C114 C116-C120 C122 C134 C135 C141 C143 C147 C148 C165 C169 C171 C172 C174 C176 C178 C180 C182 C183 C186 C188 C196-C198 C205 C214 C218 C220 C226 C228 C230 C237-C240 C247 C249 C256 C257 C261 C273 C274 C276 C277 C279 C280 C282-C284 C287 C288 C290 C294-C298 C301 C302 C310-C312 C315 C319 C323 C325-C327 C331 C336 C338 C340 C342 C345 C347 C348 C350-C352 C354 C357 C358 C360 C363 C369-C372 C374 C377 C378 C380 C385 C387 C388 C390 C394 C401 C403 C408 C409 C414 C415 C421 C424 C426 C429 C430 C433 C439 C447 C451 C452 C458 C464 C466 C467 C469 C470 C472 C475 C477 C480-C482 C484 C485 C488 C493 C495-C502 C505 C513 C517 C520-C522 C525 C531 C536-C538 C540 C543 C544 C546 C550 C551 C553 C555 C557 C562 C566 C568 C571 C572 C578 C579 C581 C583 C584 C588 C590 C591 C593 C596 C599 C601 C602 C604 C605 C608 C610 C613 C615 C620 C626 C636 C640 C642-C648 C651-C657 C659-C666 C669 C670 C672 C674 C684 C685 C691 C692 C694 C702 C703 C706 C715 C718-C722 C726 C733 C735 C745-C751 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1C104K; part number: CAP_SMD_NPOL_0-0.1UF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_100000pF_2_1
C19 C210 C698-C701 C786 C787 = CAP_SMD_POL_0: Tolerance: TOL; User Part Number: ECS-T0JD227R; part number: CAP_SMD_POL_0-220UF,5%,6.3V,CAPT_7343; signal model: DEFAULT_CAPACITOR_2.2e+08pF_2_1
C26 C27 C33-C40 C43 C46 C49 C56 C58 C59 C61 C66-C71 C74-C76 C78 C79 C85 C91 C103 C129 C140 C144 C149-C164 C166 C170 C173 C175 C177 C179 C181 C184 C185 C187 C189-C195 C199-C204 C211-C213 C215-C217 C219 C227 C234 C235 C241-C246 C248 C250-C255 C258 C260 C262 C264-C272 C275 C278 C281 C285 C286 C289 C293 C299 C300 C304-C306 C309 C316 C318 C320-C322 C330 C332-C335 C337 C339 C343 C344 C346 C349 C353 C355 C356 C361 C362 C367 C368 C373 C375 C376 C379 C381-C384 C386 C389 C391-C393 C395-C397 C400 C402 C404-C407 C410 C419 C420 C422 C423 C434 C437 C440-C446 C448-C450 C453-C457 C465 C468 C471 C473 C474 C476 C478 C479 C483 C486 C487 C489 C491 C492 C494 C503 C504 C506-C512 C514-C516 C523 C524 C527-C530 C533-C535 C539 C541 C542 C545 C547-C549 C552 C554 C556 C558 C560 C561 C563 C565 C569 C570 C573-C577 C580 C582 C585 C587 C589 C592 C594 C595 C597 C598 C600 C603 C606 C607 C609 C611 C612 C614 C617-C619 C621-C625 C628-C635 C637 C639 C641 C649 C650 C658 C671 C728 C730 C732 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1C103K; part number: CAP_SMD_NPOL_0-0.01UF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_10000pF_2_1
C28 C73 = CAP_SMD_POL_0: User Part Number: 4SP820M; Tolerance: XXX; part number: CAP_SMD_POL_0-820UF,5%,4V,CAP_SP; signal model: DEFAULT_CAPACITOR_820.000000pF_2_1
C41 C47 C136-C139 C206 C207 C229 C231 C236 C303 C314 C329 C364-C366 C398 C399 C411-C413 C427 C428 C438 C459 C463 C559 C586 C616 C627 C776 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: TAJA225K010R; part number: CAP_SMD_NPOL_0-2.2UF,5%,CAP_0805; signal model: DEFAULT_CAPACITOR_2.2e+06pF_2_1
C42 C57 = CAP_SMD_POL_0: User Part Number: 6SP680M; Tolerance: XXX; part number: CAP_SMD_POL_0-680UF,5%,6.3V,CAP_SP; signal model: DEFAULT_CAPACITOR_6.8e+08pF_2_1
C48 = CAP_SMD_NPOL_0: User Part Number: ECJ3YB2A473K; Tolerance: XXX; part number: CAP_SMD_NPOL_0-0.047UF,5%,CAP_1206; signal model: DEFAULT_CAPACITOR_47000pF_2_1
C62-C65 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1C473K; part number: CAP_SMD_NPOL_0-0.047UF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_47000pF_2_1
C81 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1C622K; part number: CAP_SMD_NPOL_0-6200PF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_6200pF_2_1
C82 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1C121K; part number: CAP_SMD_NPOL_0-120PF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_120.000000pF_2_1
C86 C95 C564 C567 = CAP_SMD_POL_0: User Part Number: JMK212BJ106MG; Tolerance: XXX; part number: CAP_SMD_POL_0-10UF,5%,10V,CAP_1206; signal model: DEFAULT_CAPACITOR_1e+07pF_2_1
C88 C94 C96-C99 C106-C109 C711-C713 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1H102K; part number: CAP_SMD_NPOL_0-0.001UF,5%,CAP_0402; signal model: DEFAULT_CAPACITOR_1000pF_2_1
C93 C167 C232 C313 C425 C777 C790 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-2FF1E105Z; part number: CAP_SMD_NPOL_0-1.0UF,5%,CAP_0805; signal model: DEFAULT_CAPACITOR_1e+06pF_2_1
C100 C124 = CAP_SMD_NPOL_0: User Part Number: ECJ-3YB2A104K; Tolerance: XXX; part number: CAP_SMD_NPOL_0-0.1UF,5%,CAP_1206; signal model: DEFAULT_CAPACITOR_100000pF_2_1
C121 C123 = CAP_SMD_POL_0: Tolerance: TOL; User Part Number: ECS-T1AD476R; part number: CAP_SMD_POL_0-47UF,5%,16V,CAPT_7343; signal model: DEFAULT_CAPACITOR_4.7e+07pF_2_1
C126 C128 C681-C683 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-2VF1C105Z; part number: CAP_SMD_NPOL_0-1UF,5%,CAP_0805; signal model: DEFAULT_CAPACITOR_1e+06pF_2_1
C130 C132 C142 C168 C208 C233 C259 C263 C291 C292 C324 C341 C359 C416 C417 C431 C432 C435 C436 C460-C462 C490 C519 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1H102K; part number: CAP_SMD_NPOL_0-0.001UF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_1000pF_2_1
C131 = CAP_SMD_POL_0: Tolerance: TOL; User Part Number: ECS-T1DD336R; part number: CAP_SMD_POL_0-33UF,5%,20V,CAPT_7343; signal model: DEFAULT_CAPACITOR_3.3e+07pF_2_1
C133 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1H101K; part number: CAP_SMD_NPOL_0-100PF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_100.000000pF_2_1
C145 C146 C696 C697 C734 C736 = CAP_SMD_POL_0: User Part Number: ECS-T0JX476RABC; Tolerance: TOL; part number: CAP_SMD_POL_0-47UF,5%,6.3V,CAPT_3528; signal model: DEFAULT_CAPACITOR_4.7e+07pF_2_1
C209 C680 = CAP_SMD_POL_0: Tolerance: TOL; User Part Number: ECS-T0JX476RABC; part number: CAP_SMD_POL_0-47UF,5%,6.3V,CAPT_7343; signal model: DEFAULT_CAPACITOR_4.7e+07pF_2_1
C307 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1H101K; part number: CAP_SMD_NPOL_0-100PF,5%,CAP_0402; signal model: DEFAULT_CAPACITOR_100.000000pF_2_1
C308 C317 C328 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1A104K; part number: CAP_SMD_NPOL_0-0.1UF,5%,CAP_0402; signal model: DEFAULT_CAPACITOR_100000pF_2_1
C418 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VC1H471J; part number: CAP_SMD_NPOL_0-470PF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_470.000000pF_2_1
C638 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VBC1C103K; part number: CAP_SMD_NPOL_0-10PF,5%,CAP_0603; signal model: DEFAULT_CAPACITOR_10.000000pF_2_1
C714 = CAP_SMD_POL_0: User Part Number: TPSC107K010R0075; Tolerance: TOL; part number: CAP_SMD_POL_0-100UF,5%,10V,CAPT_C; signal model: DEFAULT_CAPACITOR_1e+08pF_2_1
C716 C717 C782-C785 C788 C789 = CAP_SMD_POL_0: Tolerance: TOL; User Part Number: TPSC107K010R0075; part number: CAP_SMD_POL_0-100UF,5%,10V,CAPT_7343; signal model: DEFAULT_CAPACITOR_1e+08pF_2_1
C727 C729 C731 = CAP_SMD_POL_0: User Part Number: ECS-T1AD476R; Tolerance: TOL; part number: CAP_SMD_POL_0-47UF,5%,16V,CAPT_3528; signal model: DEFAULT_CAPACITOR_4.7e+07pF_2_1
C754 C758 C762 C766 C770 C778 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1E471K; part number: CAP_SMD_NPOL_0-470PF,10%,CAP_0402; signal model: DEFAULT_CAPACITOR_470.000000pF_2_1
C755 C759 C763 C767 C771 C779 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1C103K; part number: CAP_SMD_NPOL_0-0.001UF,10%,CAP_0402; signal model: DEFAULT_CAPACITOR_1000pF_2_1
C756 C760 C764 C768 C772 C780 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1A104K; part number: CAP_SMD_NPOL_0-0.1UF,10%,CAP_0402; signal model: DEFAULT_CAPACITOR_100000pF_2_1
C757 C761 C765 C769 C773 C781 = CAP_SMD_NPOL_0: User Part Number: GRM188R60J225KE01D; Tolerance: XXX; part number: CAP_SMD_NPOL_0-2.2UF,10%,CAPT_0603; signal model: DEFAULT_CAPACITOR_2.2e+06pF_2_1
C774 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-1VB1H102K; part number: CAP_SMD_NPOL_0-0.001UF,10%,CAP_0603; signal model: DEFAULT_CAPACITOR_1000pF_2_1
C775 = CAP_SMD_NPOL_0: Tolerance: XXX; User Part Number: ECJ-0EB1E471K; part number: CAP_SMD_NPOL_0-470PF,5%,CAP_0402; signal model: DEFAULT_CAPACITOR_470.000000pF_2_1
CN1-CN13 = CAPACITOR NETWORK_3: Tolerance: XXX; User Part Number: ECJ-RVF1E104Z; part number: CAPACITOR NETWORK_3-0.1UF,5%; signal model: DEFAULT_CAPACITOR_PACK_4_100000pF
CON3 = CF_HEADER_0: User Part Number: INV; Tolerance: TOL
HS1 HS2 = HEAT SINK_TO-263_1
ISO1 = OPTO ISOLATOR-A_0
J1 J108 J109 = HM-ZD-40(P)_0
J2-J6 J16-J20 J24-J30 J37 J43 J46 J47 J49 J52 J60-J62 J69 J76 J80 J83 J84 J88 J89 J91 J94 J95 J97 J99 J100 J102-J104 J106 J107 J121 J122 = LTI-SASF54GT_0
J11 J15 J23 J32 = 1364532-2_2
J31 = CONN PCB 10X2_0
J34 J75 = 2-767004-2_0
J36 = HEADER 4X2: Tolerance: TOL; User Part Number: INV
J38 J45 J54 J64 = 437-001_12
J42 J59 = TMP_201136
J48 J55 J56 J90 J111-J114 = CON2
J53 J68 = CON20A
J57 J58 = AGILENT_E5387A
J63 J85 J87 = CONN PCB 5X2-S
J72 J77 J81 J86 J93 J98 J101 J105 = SMA_EDGE_LAUNCH_13
J78 = HDR2X10
J79 = HDR2X7
J92 = HDR2X20
J123 = HEADER 2X2: Tolerance: TOL; User Part Number: INV
J124 = CONN_DSUB_9PIN_DOUBLE_5
PMCJN1 = HEADER 32X2_0
PMCJN2 = HEADER 32X2_1
R2 = R: User Part Number: NPR1TTE56LJ; Tolerance: XXX; part number: R-0.056,5%,THRU_HOLE; signal model: DEFAULT_RESISTOR_0.056OHM_2_1
R3 R6 R18 R33 R43 R60 R61 R86 R135 R137 R138 R150-R157 R165 R167 R168 R214 R270-R277 R322 R323 R342 R343 R346 R347 = R: User Part Number: NRC04F1000TR; Tolerance: XXX; part number: R-100,2%,RES_0402; signal model: DEFAULT_RESISTOR_100.000000OHM_2_1
R4 = R: User Part Number: NRC06F1040TR; Tolerance: XXX; part number: R-104,5%,RES_0603; signal model: DEFAULT_RESISTOR_104.000000OHM_2_1
R5 = R: User Part Number: NRC06F20R0TR; Tolerance: XXX; part number: R-20,5%,RES_0603; signal model: DEFAULT_RESISTOR_20.000000OHM_2_1
R7 R11 R23 R30 R70 R73 R236 R238 = R: User Part Number: NRC06F56R0TR; Tolerance: XXX; part number: R-56,2%,RES_0603; signal model: DEFAULT_RESISTOR_56.000000OHM_2_1
R15 R87 R90 R91 R94 R192 R193 R195 = R: User Part Number: NRC04F1400TR; Tolerance: XXX; part number: R-104,5%,RES_0402; signal model: DEFAULT_RESISTOR_104.000000OHM_2_1
R16 R88 R89 R92 R93 R191 R194 R196 = R: User Part Number: NRC04F78R7TR; Tolerance: XXX; part number: R-78.7,5%,RES_0402; signal model: DEFAULT_RESISTOR_78.700000OHM_2_1
R17 = R: User Part Number: NRC04F6651TR; Tolerance: XXX; part number: R-6.65K,5%,RES_0402; signal model: DEFAULT_RESISTOR_6650OHM_2_1
R19 = R: User Part Number: NRC04F4421TR; Tolerance: XXX; part number: R-4.42K,5%,RES_0402; signal model: DEFAULT_RESISTOR_4420OHM_2_1
R21 R344 = R: User Part Number: NRC04Z0; Tolerance: XXX; part number: R-0,5%,RES_0402; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R27 R35 R40 R46-R48 = R: User Part Number: NRC04F1620TR; Tolerance: XXX; part number: R-162,5%,RES_0402; signal model: DEFAULT_RESISTOR_162.000000OHM_2_1
R28 R31 R32 R74 R75 R225 = R: User Part Number: NRC04J1001TR; Tolerance: XXX; part number: R-1.0K,5%,RES_0402; signal model: DEFAULT_RESISTOR_1000.000000OHM_2_1
R34 = R: User Part Number: NRC04F2701TR; Tolerance: XXX; part number: R-2.7K,5%,RES_0402; signal model: DEFAULT_RESISTOR_2700OHM_2_1
R37 R42 R51 R55 R76 R77 R98 R123 R133 R142-R148 R158 R216 R231-R233 R279-R281 R289-R294 R304 R318 R319 R358-R360 = R: User Part Number: NRC06J1002TR; Tolerance: XXX; part number: R-10.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_10000OHM_2_1
R39 R41 R44 R53 R56 R57 R68 R119 R120 R130 R140 R159 R160 R163 R164 R169 R170 R172 R207 R247 R260 R262-R269 R278 R282-R286 R296 R299 R303 R305 = R: User Part Number: NRC06J1001TR; Tolerance: XXX; part number: R-1.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_1000.000000OHM_2_1
R52 R127 = R: User Part Number: NRC04J220TR; Tolerance: XXX; part number: R-22,5%,RES_0402; signal model: DEFAULT_RESISTOR_22.000000OHM_2_1
R62 R71 R190 R202 = R: User Part Number: NRC06J4R7TR; Tolerance: XXX; part number: R-4.7,5%,RES_0603; signal model: DEFAULT_RESISTOR_4.700000OHM_2_1
R65-R67 R80-R85 R99 R100 = R: User Part Number: NRC06J2501TR; Tolerance: XXX; part number: R-2.5K,2%,RES_0603; signal model: DEFAULT_RESISTOR_2500OHM_2_1
R101 = R: User Part Number: NRC06J2001TR; Tolerance: XXX; part number: R-2.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_2000OHM_2_1
R102 R121 R125 R128 = R: User Part Number: NRC06J1102TR; Tolerance: XXX; part number: R-11.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_11000OHM_2_1
R103 R104 R116 R118 = R: User Part Number: ERJ3EKF24.9V; Tolerance: XXX; part number: R-24.9,5%,RES_0603; signal model: DEFAULT_RESISTOR_24.900000OHM_2_1
R105-R114 = R: User Part Number: NRC06J6003TR; Tolerance: XXX; part number: R-60.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_60000OHM_2_1
R115 = R: User Part Number: NRC06F4990TR; Tolerance: XXX; part number: R-499,5%,RES_0603; signal model: DEFAULT_RESISTOR_499.000000OHM_2_1
R117 = R: User Part Number: NRC06F2202TR; Tolerance: XXX; part number: R-22K,5%,RES_0603; signal model: DEFAULT_RESISTOR_22000OHM_2_1
R122 = R: User Part Number: NRC06F3002TR; Tolerance: XXX; part number: R-30K,5%,RES_0603; signal model: DEFAULT_RESISTOR_30000OHM_2_1
R124 R204 = R: User Part Number: NRC06J2000TR; Tolerance: XXX; part number: R-200,2%,RES_0603; signal model: DEFAULT_RESISTOR_200.000000OHM_2_1
R126 R149 R171 R180-R184 R186 R203 R208 R212 R345 R355 = R: User Part Number: NRC04F1000TR; Tolerance: XXX; part number: R-NI,5%,RES_0402
R129 = R: User Part Number: NRC04J230TR; Tolerance: XXX; part number: R-23,5%,RES_0603; signal model: DEFAULT_RESISTOR_23.000000OHM_2_1
R131 R132 R242 = R: User Part Number: NRC06F2500TR; Tolerance: XXX; part number: R-250,2%,RES_0603; signal model: DEFAULT_RESISTOR_250.000000OHM_2_1
R134 R261 R298 R300 R301 = R: User Part Number: NRC06J47R0TR; Tolerance: XXX; part number: R-47,5%,RES_0603; signal model: DEFAULT_RESISTOR_47.000000OHM_2_1
R136 = R: User Part Number: ERJ-2GEJ56X; Tolerance: XXX; part number: R-56,2%,RES_0402; signal model: DEFAULT_RESISTOR_56.000000OHM_2_1
R139 R141 = R: User Part Number: NRC06F49R9TR; Tolerance: XXX; part number: R-49.9,2%,RES_0603; signal model: DEFAULT_RESISTOR_49.900000OHM_2_1
R161 R162 R173 R174 R205 R206 R209-R211 R217-R221 R224 R226-R230 R235 R237 R239 R241 = R: User Part Number: NRC06J4701TR; Tolerance: XXX; part number: R-4.7K,5%,RES_0603; signal model: DEFAULT_RESISTOR_4700OHM_2_1
R175 = R: User Part Number: EXB-2HV102JV; Tolerance: XXX; part number: R-20.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_20000OHM_2_1
R176 R177 R243 R244 = R: User Part Number: NRC04F49R9TR; Tolerance: XXX; part number: R-49.9,5%,RES_0402; signal model: DEFAULT_RESISTOR_49.900000OHM_2_1
R178 R179 R259 R324 R326 R327 R334-R337 R348 R349 R361 = R: User Part Number: NRC06Z0; Tolerance: XXX; part number: R-0,5%,RES_0603; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R185 = R: Tolerance: XXX; User Part Number: NRC10F2000TR; part number: R-200,5%,RES_0805; signal model: DEFAULT_RESISTOR_200.000000OHM_2_1
R187 = R: Tolerance: XXX; User Part Number: NRC10F2260TR; part number: R-226,5%,RES_0805; signal model: DEFAULT_RESISTOR_226.000000OHM_2_1
R189 = R: Tolerance: XXX; User Part Number: NRC04F1002TR; part number: R-10K,5%,RES_0805; signal model: DEFAULT_RESISTOR_10000OHM_2_1
R215 = R: User Part Number: NRC04F1002TR; Tolerance: XXX; part number: R-10K,5%,RES_0402; signal model: DEFAULT_RESISTOR_10000OHM_2_1
R222 = R: User Part Number: ERJ-2RKF93.10V; Tolerance: XXX; part number: R-93,5%,RES_0603; signal model: DEFAULT_RESISTOR_93.000000OHM_2_1
R223 = R: User Part Number: ERJ-2RKF158.0V; Tolerance: XXX; part number: R-158,5%,RES_0603; signal model: DEFAULT_RESISTOR_158.000000OHM_2_1
R248 = R: User Part Number: NRC06F7870TR; Tolerance: XXX; part number: R-787,5%,RES_0603; signal model: DEFAULT_RESISTOR_787.000000OHM_2_1
R249-R258 = R: User Part Number: NRC06F1502TR; Tolerance: XXX; part number: R-15.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_15000OHM_2_1
R297 = R: User Part Number: NRC06F7870TR; Tolerance: XXX; part number: R-78.7,5%,RES_0603; signal model: DEFAULT_RESISTOR_78.700000OHM_2_1
R306 R307 R353 = R: User Part Number: NRC06J5601TR; Tolerance: XXX; part number: R-5.6K,5%,RES_0603; signal model: DEFAULT_RESISTOR_5600OHM_2_1
R329-R333 R338-R341 R350 R351 = R: User Part Number: NRC06J1002TR; Tolerance: XXX; part number: R-NI,5%,RES_0603
R352 = R: Tolerance: XXX; User Part Number: ERJ-6GEYJ754V; part number: R-750K,5%,RES_0805; signal model: DEFAULT_RESISTOR_750000OHM_2_1
R354 = R: User Part Number: NRC06J3001TR; Tolerance: XXX; part number: R-3.0K,5%,RES_0603; signal model: DEFAULT_RESISTOR_3000OHM_2_1
R357 = R: User Part Number: NRC06J6201TR; Tolerance: XXX; part number: R-6.2K,5%,RES_0603; signal model: DEFAULT_RESISTOR_6200OHM_2_1
RJ1 = RJ45INTLED_0
RN5 RN23-RN32 = RES_PACK: Tolerance: XXX; User Part Number: EXB-2HV560JV; part number: RES_PACK-56,5%; signal model: DEFAULT_RESISTOR_PACK_8_56.000000OHM
RN14 RN37-RN39 = RES_PACK: Tolerance: XXX; User Part Number: EXB-2HV102JV; part number: RES_PACK-1.0K,5%; signal model: DEFAULT_RESISTOR_PACK_8_1000.000000OHM
RN15-RN18 = RES_PACK: User Part Number: EXB-2HV103JV; Tolerance: XXX; part number: RES_PACK-10K,5%; signal model: DEFAULT_RESISTOR_PACK_8_10000OHM
RN19 RN20 = RES_PACK: User Part Number: EXB-2HV103JV; Tolerance: XXX; part number: RES_PACK-10.0K,5%; signal model: DEFAULT_RESISTOR_PACK_8_10000OHM
RN21 RN22 RN33-RN36 = RES_PACK: User Part Number: EXB-2HV221JV; Tolerance: XXX; part number: RES_PACK-220,5%; signal model: DEFAULT_RESISTOR_PACK_8_220.000000OHM
U1 U42 = MIC29502BU_1
U2 = LM1587_0
U4 = MC100EP33_0
U5 U12 = MAX1619_4
U6 = MC100EP139_0
U7 = U7_EP2S60F1020: User Part Number: u7_ep2s60f1020
U8 = QD48T033050_0
U9 = MC100EPT26_0: User Part Number: INV; Tolerance: TOL
U10 = ICS87946-01_4
U11 = LAN91C111_2
U13 = ICS8304AM
U14 = MAX1953_1
U15 = EP1S40F1020_5
U17 = FDS6898A
U18 U32 = ICS8545_TSSOP_0
U19-U21 = QS32X2245/SO_6
U22-U24 U39 U52 = QS3861/SO_2
U25 U26 U34 = 74ALVCH16244_2
U27 = XENPAK_1
U28 U33 = LTC1386_0
U29 U30 = EPC16U_PQFP100
U31 = AM29DL640D
U36 U37 = FAN5066_0
U38 = MIC5209BM: Tolerance: TOL; User Part Number: INV
U43 U44 = MC14490: Tolerance: TOL; User Part Number: INV
U45 = QD48T20050_2
U46 U47 = ICS83026I_2
U53 = LP2995M
U59 = FDC6323L_0: Tolerance: TOL; User Part Number: INV
U60 = MIC5219BM5_1: Tolerance: TOL; User Part Number: INV
XU2 = PARALLELBUS_DIMM
Y1-Y3 = CRYSTAL1-4/SM_1
Y4 = OSC_SMT

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
4P_OSC
  rect 2.032x1.829 smd: 1(-2.1,2.54) 2(-2.1,-2.54) 3(2.1,-2.54) 4(2.1,2.54)
8_PINS_SURFACE_MOUNT
  rect 1.143x0.559 smd: 1(-0.762,1.2) 2(-0.762,0.4) 3(-0.762,-0.4) 4(-0.762,-1.2) 5(0.762,-1.2) 6(0.762,-0.4) 7(0.762,0.4) 8(0.762,1.2)
10_PIN_CONNECTOR
  rect 3.175x1.27 smd: 1(-2.731,5.08) 2(2.731,5.08) 3(-2.731,2.54) 4(2.731,2.54) 5(-2.731,0) 6(2.731,0) 7(-2.731,-2.54) 8(2.731,-2.54) 9(-2.731,-5.08) 10(2.731,-5.08)
16_PIN_SMD
  rect 0.889x0.432 smd: 1(-0.944,1.839) 8(-0.944,-1.839) 9(0.944,-1.839) 16(0.944,1.839)
  rect 0.889x0.254 smd: 2(-0.944,1.25) 3(-0.944,0.75) 4(-0.944,0.25) 5(-0.944,-0.25) 6(-0.944,-0.75) 7(-0.944,-1.25) 10(0.944,-1.25) 11(0.944,-0.75) 12(0.944,-0.25) 13(0.944,0.25) 14(0.944,0.75) 15(0.944,1.25)
BRICK7
  rect 2.54x2.54 hole 1.575: 1(0,0)
  round 2.54 hole 1.575: 2(0,-8.89) 3(0,-17.78) 4(50.8,-18.415) 5(50.8,-12.065) 6(50.8,-5.715) 7(50.8,0.635)
BRICK_8
  rect 2.54x2.54 hole 1.575: 1(0,0)
  round 2.54 hole 1.575: 2(0,-7.62) 3(0,-15.24) 5(50.8,-11.43) 6(50.8,-7.62) 7(50.8,-3.81)
  round 3.099 hole 2.159: 4(50.8,-15.24) 8(50.8,0)
CAP_0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
CAP_0603
  rect 0.813x1.067 smd: 1(0,0.85) 2(0,-0.85)
CAP_0805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
CAP_1206
  rect 1.778x1.6 smd: 1(0,1.4) 2(0,-1.4)
CAP_SP
  rect 1.524x1.524 hole 1.067: 1(0,0)
  round 1.524 hole 1.067: 2(0,-5)
CAPT_0603
  rect 0.813x1.067 smd: 1(0,0.85) 2(0,-0.85)
CAPT_3528
  rect 2.032x2.286 smd: 1(-1.524,0) 2(1.524,0)
CAPT_7343
  rect 2.54x3.556 smd: 1(-3.302,0) 2(3.302,0)
CAPT_C
  rect 2.032x2.794 smd: 1(-2.286,0) 2(2.286,0)
CFCONN50P
  rect 2.489x5.994 smd: (-22.86,-12.532) (22.86,-12.532)
  round 0.127 hole 1.194 unplated: (-21.828,5.593) (21.828,5.593)
  round 0.127 hole 2.286 unplated: (-20.491,3.216) (20.491,3.216)
  rect 0.432x1.981 smd: 1(-15.557,5.791) 2(-14.287,5.791) 3(-13.018,5.791) 4(-11.748,5.791) 5(-10.477,5.791) 6(-9.207,5.791) 7(-7.938,5.791) 8(-6.668,5.791) 9(-5.397,5.791) 10(-4.128,5.791) 11(-2.857,5.791) 12(-1.587,5.791) 13(-0.318,5.791) 14(0.953,5.791) 15(2.223,5.791) 16(3.493,5.791) 17(4.763,5.791) 18(6.032,5.791) 19(7.303,5.791) 20(8.572,5.791) 21(9.842,5.791) 22(11.113,5.791) 23(12.383,5.791) 24(13.652,5.791) 25(14.922,5.791) 26(-14.922,5.791) 27(-13.652,5.791) 28(-12.383,5.791) 29(-11.113,5.791) 30(-9.842,5.791) 31(-8.572,5.791) 32(-7.303,5.791) 33(-6.032,5.791) 34(-4.763,5.791) 35(-3.493,5.791) 36(-2.223,5.791) 37(-0.953,5.791) 38(0.318,5.791) 39(1.587,5.791) 40(2.857,5.791) 41(4.128,5.791) 42(5.397,5.791) 43(6.668,5.791) 44(7.938,5.791) 45(9.207,5.791) 46(10.477,5.791) 47(11.748,5.791) 48(13.018,5.791) 49(14.287,5.791) 50(15.557,5.791)
CON120_HM-ZD
  rect 1.118x1.118 hole 0.61: 1A(0,0)
  round 1.118 hole 0.61: 1B(0,1.5) 1BG(0,3) 1C(0,4.5) 1D(0,6) 1DG(0,7.5) 1E(0,9) 1F(0,10.5) 1FG(0,12) 1G(0,13.5) 1H(0,15) 1HG(0,16.5) 2A(-2.5,0) 2B(-2.5,1.5) 2BG(-2.5,3) 2C(-2.5,4.5) 2D(-2.5,6) 2DG(-2.5,7.5) 2E(-2.5,9) 2F(-2.5,10.5) 2FG(-2.5,12) 2G(-2.5,13.5) 2H(-2.5,15) 2HG(-2.5,16.5) 3A(-5,0) 3B(-5,1.5) 3BG(-5,3) 3C(-5,4.5) 3D(-5,6) 3DG(-5,7.5) 3E(-5,9) 3F(-5,10.5) 3FG(-5,12) 3G(-5,13.5) 3H(-5,15) 3HG(-5,16.5) 4A(-7.5,0) 4B(-7.5,1.5) 4BG(-7.5,3) 4C(-7.5,4.5) 4D(-7.5,6) 4DG(-7.5,7.5) 4E(-7.5,9) 4F(-7.5,10.5) 4FG(-7.5,12) 4G(-7.5,13.5) 4H(-7.5,15) 4HG(-7.5,16.5) 5A(-10,0) 5B(-10,1.5) 5BG(-10,3) 5C(-10,4.5) 5D(-10,6) 5DG(-10,7.5) 5E(-10,9) 5F(-10,10.5) 5FG(-10,12) 5G(-10,13.5) 5H(-10,15) 5HG(-10,16.5) 6A(-12.5,0) 6B(-12.5,1.5) 6BG(-12.5,3) 6C(-12.5,4.5) 6D(-12.5,6) 6DG(-12.5,7.5) 6E(-12.5,9) 6F(-12.5,10.5) 6FG(-12.5,12) 6G(-12.5,13.5) 6H(-12.5,15) 6HG(-12.5,16.5) 7A(-15,0) 7B(-15,1.5) 7BG(-15,3) 7C(-15,4.5) 7D(-15,6) 7DG(-15,7.5) 7E(-15,9) 7F(-15,10.5) 7FG(-15,12) 7G(-15,13.5) 7H(-15,15) 7HG(-15,16.5) 8A(-17.5,0) 8B(-17.5,1.5) 8BG(-17.5,3) 8C(-17.5,4.5) 8D(-17.5,6) 8DG(-17.5,7.5) 8E(-17.5,9) 8F(-17.5,10.5) 8FG(-17.5,12) 8G(-17.5,13.5) 8H(-17.5,15) 8HG(-17.5,16.5) 9A(-20,0) 9B(-20,1.5) 9BG(-20,3) 9C(-20,4.5) 9D(-20,6) 9DG(-20,7.5) 9E(-20,9) 9F(-20,10.5) 9FG(-20,12) 9G(-20,13.5) 9H(-20,15) 9HG(-20,16.5) 10A(-22.5,0) 10B(-22.5,1.5) 10BG(-22.5,3) 10C(-22.5,4.5) 10D(-22.5,6) 10DG(-22.5,7.5) 10E(-22.5,9) 10F(-22.5,10.5) 10FG(-22.5,12) 10G(-22.5,13.5) 10H(-22.5,15) 10HG(-22.5,16.5)
